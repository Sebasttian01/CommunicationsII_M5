options:
  parameters:
    generate_options: qt_gui
    id: Reto
    output_language: python
    title: Real-time Programing Challenge
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/comu2_grupoc1/Descargas/Yerba Brava - La Cumbia de los Trapos.mp4
    repeat: 'True'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk (gr. sync_block ):\n\n    def __init__(self):  # only default arguments here\n        gr.sync_block.__init__(\n            self,\n            name='Promedios_de_tiempo',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[np.float32,np.float32,np.float32,np.float32,np.float32]\n\n        )\n        self.acum_anterior = 0\n        self.Ntotales = 0\n        self.acum_anterior1 = 0\n        self.acum_anterior2 = 0\n        \n        \n    def work(self, input_items, output_items):\n        x = input_items[0] #Senial de entrada\n        y0 = output_items[0] #Promedio de la Senial\n        y1 = output_items[1] #Media de la Senial\n        y2 = output_items[2] #RMS de la senial\n        y3 = output_items[3] #Potencia promedio de la senial\n        y4 = output_items[4] #Desviacion estandar de la senial\n        \n        #Calculo del promedio\n        N = len(x)\n        self.Ntotales = self.Ntotales + N\n        acumulado = self.acum_anterior + np.cumsum(x)\n        self.acum_anterior = acumulado[N-1]\n        y0[:]=acumulado/self.Ntotales\n        \n        #Calculo de la media cuadratica\n        x2 = np.multiply(x,x)\n        acumulado1 = self.acum_anterior1 + np.cumsum(x2)\n        self.acum_anterior1 = acumulado1[N-1]\n        y1[:]=acumulado1/self.Ntotales\n        \n        #Calculo ed la RMS\n        y2[:] = np.sqrt(y1)\n        \n        #Calculo de la potencia promedio\n        y3[:] = np.multiply(y2,y2)\n        \n        #Calculo de la desviacion estandar\n        x3 = np.multiply(x-y0,x-y0)\n        acumulado2 = self.acum_anterior2 + np.cumsum(x3)\n        self.acum_anterior2 = acumulado2[N-1]\n        y4[:] = np.sqrt(acumulado2/self.Ntotales)\n        \n        return len(x)\n        \n    \n  \n"
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: MEDIA CUADRATICA
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: RMS
    type: float
  states: {}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: DESVIACION ESTANDAR
    type: float
  states: {}
- name: qtgui_number_sink_1_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: POTENCIA PROMEDIO
    type: float
  states: {}
- name: qtgui_number_sink_1_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: MEDIA
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', epy_block_2, '0']
- [epy_block_2, '0', qtgui_number_sink_1_3, '0']
- [epy_block_2, '1', qtgui_number_sink_1, '0']
- [epy_block_2, '2', qtgui_number_sink_1_0, '0']
- [epy_block_2, '3', qtgui_number_sink_1_2, '0']
- [epy_block_2, '4', qtgui_number_sink_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
