options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Es un modulador M-PAM. La entrada y la salida es de tipo Byte, pero en la entrada lo que se esperan son unos y ceros, osea que la entrada es una senal PCM.
    generate_options: hb
    id: b_M_PAM_bb
    output_language: python
    title: b_M_PAM_bb
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Nbps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: M
  id: parameter
  parameters:
    label: M
    type: intx
    value: '4'
  states: {}
- name: Nbps
  id: parameter
  parameters:
    value: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: Nbps
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: Nbps
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: e_bipol_to_unip
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de bipolar a unipolar una senal tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_bipol_to_unip',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):

              output_items[0][:] = (input_items[0]+1)/2
              return len(output_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {state: disabled}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {state: disabled}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_pack_k_bits_bb_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', pad_sink_1, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', pad_sink_1_0, '0']
- [e_bipol_to_unip, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [pad_source_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [pad_source_0_0, '0', e_bipol_to_unip, '0']

metadata:
  file_format: 1
