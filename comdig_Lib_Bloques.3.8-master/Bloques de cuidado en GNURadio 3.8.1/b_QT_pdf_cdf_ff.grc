options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: Hecho por Homero Ortega. Recibe an input with values between Xmin and Xmax and calculate the Probaility Density Function (PDF), as well as Cumulative Distribution Function (CDF) dinamically.
    generate_options: hb_qt_gui
    id: b_pdf_cdf_ff
    output_language: python
    title: b_pdf_cdf_ff
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: step
  id: variable
  parameters:
    value: float(Xmax-Xmin)/N
  states: {}
- name: EjeX
  id: parameter
  parameters:
    label: Nombre Eje Horiz
    value: '''potencia'''
  states: {}
- name: Note
  id: note
  parameters:
    note: Esta ramificacion de abajo es la que introduce las fluctuaciones en magnitud
  states: {}
- name: Xmax
  id: parameter
  parameters:
    label: Xmax
    type: eng_float
    value: '4.'
  states: {}
- name: Xmin
  id: parameter
  parameters:
    label: Xmin
    type: eng_float
    value: '-4.'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: e_vector_integrate_ff
  id: epy_block
  parameters:
    N: N
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom scipy import integrate\n\nclass e_vector_integrate_ff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Hecho por Homero Ortega. Integrates de input signal en the lenght N of the vector. step is the distance between samples. So that every N samples integration is reset\"\"\"\n\n    def __init__(self, step=0.01, N=1024):  # only default arguments here\n        gr.sync_block.__init__(\n            self,\n            name='e_vector_integrate_ff',   # will show up in GRC\n            in_sig=[(np.float32, N)],\n            out_sig=[(np.float32,N)]\n        )\n        self.N = N\n        self.step = step\n\n    def work(self, input_items, output_items):\n        output_items[0][:]=integrate.cumtrapz(input_items[0],dx=self.step,initial=0)\n        # print(\"dx=\",self.step)\n        return len(output_items[0])\n\n"
    step: step
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pdf2_ff
  id: epy_block
  parameters:
    N: N
    Xmax: Xmax
    Xmin: Xmin
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from scipy import integrate
      import scipy.stats

      class e_pdf2_ff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Hecho por Homero Ortega. Xmin is the minimum value that the input signal can take, Xmax is the maximum value that the input signal can take; N es the number of steps the signal will be analized in amplitud and is the number of samples for the histogram"""

          def __init__(self, Xmin=-1., Xmax=1., N=1024):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_pdf2_ff',   # will show up in GRC
                  in_sig=[(np.float32, N)],
                  out_sig=[(np.float32,N)]
              )
              self.Xmin = Xmin
              self.Xmax = Xmax
              self.N = N
              self.X=np.linspace(self.Xmin,self.Xmax,self.N) # Se le pueden dar menos valores, pero el bloque seria de tipo decimador
              self.counts=np.array([0.]*self.N)
              self.N_hist=0. #numero de histogramas procesados
              
          def work(self, input_items, output_items):
              
              x=input_items[0] # las muestras entrantes a analizar
              h=np.histogram(x,bins=self.N, range=(self.Xmin, self.Xmax)) # h[0] es el histograma propiamente, h[1] los bins
              hist_dist=scipy.stats.rv_histogram(h) # objeto que identifica muchos parametros de un histograma incluyento pdf
              pdf=hist_dist.pdf(self.X) # es la pdf instantanea (del vector actual)

              # cdf=hist_dist.cdf(self.X) # Este seria el comando si necesitamos cdf en vez de pdf

              self.N_hist += 1     # se eleva el contador de histrogramas calculados
              self.counts += pdf  # pdf acumulada
              output_items[0][:]=self.counts/(self.N_hist)   # pdf promediada

              return len(output_items[0])
  states: {}
- name: pdf_ff
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from scipy import integrate

      class e_pdf_ff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Hecho por Homero Ortega. Xmin is the minimum value that the input signal can take, Xmax is the maximum value that the input signal can take; N es the number of steps the signal will be analized in amplitud and is the number of samples for the histogram"""

          def __init__(self, Xmin=-1., Xmax=1., N=1024):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_pdf_ff',   # will show up in GRC
                  in_sig=[(np.float32, N)],
                  out_sig=[(np.float32,N)]
              )
              self.Xmin = Xmin
      	self.Xmax = Xmax
      	self.N = N
              self.counts=np.array([0]*self.N)
              self.N_hist=0. #numero de histogramas procesados
              self.step=float(Xmax-Xmin)/N

          def work(self, input_items, output_items):
              out0=output_items[0]
              x=input_items[0] # las muestras entrantes a analizar
              h=np.histogram(x,bins=self.N, range=(self.Xmin, self.Xmax))
              self.N_hist += 1
              self.counts += h[0] # h es una matrix, el histograma esta en h[0]
              pdf=self.counts/(self.N_hist*self.N) # propability density function
              out0[:]=pdf
              return len(output_items[0])
  states: {state: disabled}
- name: pdf_max
  id: parameter
  parameters:
    label: pdf_max
    type: eng_float
    value: '0.025'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Cumulative Distribution Function (CDF )"'
    showports: 'True'
    vlen: N
    width1: '3'
    x_axis_label: EjeX
    x_start: Xmin
    x_step: step
    y_axis_label: '"PDF"'
    ymax: '1.'
    ymin: '0.'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    name: '"Probability Density Function (PDF)"'
    showports: 'True'
    vlen: N
    width1: '3'
    x_axis_label: EjeX
    x_start: Xmin
    x_step: (Xmax-Xmin)/N
    y_axis_label: '"PDF"'
    ymax: pdf_max
    ymin: '0.'
  states: {}

connections:
- [blocks_stream_to_vector_0_0, '0', pdf2_ff, '0']
- [e_vector_integrate_ff, '0', qtgui_vector_sink_f_0_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [pdf2_ff, '0', e_vector_integrate_ff, '0']
- [pdf2_ff, '0', qtgui_vector_sink_f_0_0_0, '0']

metadata:
  file_format: 1
