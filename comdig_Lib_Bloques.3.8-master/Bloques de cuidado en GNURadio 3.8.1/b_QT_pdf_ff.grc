options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Hecho por Homero Ortega. Recibe an input with values between Xmin and Xmax and calculate the Probaility Density Function (PDF) dinamically.
    generate_options: hb_qt_gui
    id: b_pdf_ff
    output_language: python
    title: b_pdf_ff
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: step
  id: variable
  parameters:
    value: float(Xmax-Xmin)/N
  states: {state: disabled}
- name: EjeX
  id: parameter
  parameters:
    label: Nombre Eje Horiz
    value: '''potencia'''
  states: {}
- name: Note
  id: note
  parameters:
    note: Esta ramificacion de abajo es la que introduce las fluctuaciones en magnitud
  states: {}
- name: Xmax
  id: parameter
  parameters:
    label: Xmax
    type: eng_float
    value: '4.'
  states: {}
- name: Xmin
  id: parameter
  parameters:
    label: Xmin
    type: eng_float
    value: '-4.'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pdf_ff
  id: epy_block
  parameters:
    N: N
    Xmax: Xmax
    Xmin: Xmin
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      #from scipy import integrate
      import scipy.stats

      class e_pdf_ff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Hecho por Homero Ortega. Xmin is the minimum value that the input signal can take, Xmax is the maximum value that the input signal can take; N es the number of steps the signal will be analized in amplitud and is the number of samples for the histogram"""

          def __init__(self, Xmin=-1., Xmax=1., N=1024):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_pdf_ff',   # will show up in GRC
                  in_sig=[(np.float32, N)],
                  out_sig=[(np.float32,N)]
              )
              self.Xmin = Xmin
              self.Xmax = Xmax
              self.N = N
              self.X=np.linspace(self.Xmin,self.Xmax,self.N) # Se le pueden dar menos valores, pero el bloque seria de tipo decimador
              self.counts=np.array([0.]*self.N)
              self.N_hist=0. #numero de histogramas procesados
              
          def work(self, input_items, output_items):
           
              x=input_items[0] # las muestras entrantes a analizar
              h=np.histogram(x,bins=self.N, range=(self.Xmin, self.Xmax)) # h[0] es el histograma propiamente, h[1] los bins
              hist_dist=scipy.stats.rv_histogram(h) # objeto que identifica muchos parametros de un histograma incluyento pdf
              pdf=hist_dist.pdf(self.X) # es la pdf instantanea (del vector actual)

              # cdf=hist_dist.cdf(self.X) # Este seria el comando si necesitamos cdf en vez de pdf

              self.N_hist += 1     # se eleva el contador de histrogramas calculados
              self.counts += pdf  # pdf acumulada
              output_items[0][:]=self.counts/(self.N_hist)   # pdf promediada

              return len(output_items[0])
  states: {}
- name: pdf_max
  id: parameter
  parameters:
    label: pdf_max
    type: eng_float
    value: '0.025'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"Probability Density Function (PDF)"'
    showports: 'True'
    vlen: N
    width1: '3'
    x_axis_label: EjeX
    x_start: Xmin
    x_step: (Xmax-Xmin)/N
    y_axis_label: '"PDF"'
    ymax: pdf_max
    ymin: '0.'
  states: {}

connections:
- [blocks_stream_to_vector_0_0, '0', pdf_ff, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [pdf_ff, '0', qtgui_vector_sink_f_0_0_0, '0']

metadata:
  file_format: 1
