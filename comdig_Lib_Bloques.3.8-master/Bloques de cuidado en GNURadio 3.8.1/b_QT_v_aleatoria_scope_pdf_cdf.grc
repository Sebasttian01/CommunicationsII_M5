options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Some parameters of a random variable can visualized, like: the mean, the RMS value, the mean power, the PSD,, PDF, CDF the time signal. Parameters used: samp_rate - the sample rate of the signal; N_time - the number of time samples to be shown; N_frec- the number of frequency pointss to be shown '
    generate_options: hb_qt_gui
    id: b_v_aleatoria_scope_pdf_cdf_f
    output_language: python
    title: b_v_aleatoria_scope_pdf_cdf_f
  states: {}

blocks:
- name: Mean_reset
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,3,1,1
    label: Push here to restart averaging procces
    pressed: '0'
    released: '1'
    type: int
    value: '1'
  states: {}
- name: E3TRadio_mean_meter_0
  id: E3TRadio_mean_meter
  parameters:
    reset: Mean_reset
  states: {}
- name: E3TRadio_mean_meter_0_0
  id: E3TRadio_mean_meter
  parameters:
    reset: Mean_reset
  states: {}
- name: N_frec
  id: parameter
  parameters:
    label: N_frec
    value: '2014'
  states: {}
- name: N_time
  id: parameter
  parameters:
    label: N_time
    value: '2014'
  states: {}
- name: V_p
  id: parameter
  parameters:
    label: Valor pico
    type: eng_float
    value: '2014'
  states: {}
- name: b_PSD_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: N_frec
    Titulo: '''PSD ( linear scale)'''
    Ymax: 1./samp_rate
    gui_hint: 2,0,1,2
    samp_rate: '22000'
  states: {}
- name: b_cdf_ff_0
  id: b_cdf_ff
  parameters:
    EjeX: '''potencia'''
    Xmax: V_p
    Xmin: '-V_p'
    gui_hint: 2,2,1,2
  states: {}
- name: b_pdf_ff_0
  id: b_pdf_ff
  parameters:
    EjeX: '''potencia'''
    Xmax: V_p
    Xmin: '-V_p'
    gui_hint: 1,2,1,2
    pdf_max: '0.4'
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: In
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,1
    label1: The mean
    max: '2'
    min: '-2'
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,1,1,1
    label1: Mean square (Mean Power)
    max: '2'
    min: '-2'
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,2,1,1
    label1: VRMS instantaneous
    max: '2'
    min: '-2'
    name: ''
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    label1: '.'
    name: '"signal in time"'
    size: N_time
    srate: samp_rate
    type: float
    width1: '3'
    ymax: V_p
    ymin: '-V_p'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Fmuestreo
    value: '22000'
  states: {}

connections:
- [E3TRadio_mean_meter_0, '0', qtgui_number_sink_0_0_0_0_0, '0']
- [E3TRadio_mean_meter_0_0, '0', qtgui_number_sink_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', E3TRadio_mean_meter_0_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0_0_0_0_0_0_0, '0']
- [pad_source_2, '0', E3TRadio_mean_meter_0, '0']
- [pad_source_2, '0', b_PSD_0, '0']
- [pad_source_2, '0', b_cdf_ff_0, '0']
- [pad_source_2, '0', b_pdf_ff_0, '0']
- [pad_source_2, '0', blocks_multiply_xx_0, '0']
- [pad_source_2, '0', blocks_multiply_xx_0, '1']
- [pad_source_2, '0', blocks_rms_xx_0, '0']
- [pad_source_2, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
