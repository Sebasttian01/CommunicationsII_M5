options:
  parameters:
    author: estudiantes e3t
    category: '''[comdiguis]'''
    generate_options: hb
    id: b_VCO_2021si_fc
    output_language: python
    title: b_VCO_2021si_fc
  states: {}

blocks:
- name: E3TRadio_acumulador_truncado_ff_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: '0'
    N: Sps
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    value: '8'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.pi*2/samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, ):  # only default arguments here
              """hecho por estudiantes e3t 2021"""
              gr.sync_block.__init__(
                  self,
                  name='e_EC_fc',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.complex64]
              )
             

          def work(self, input_items, output_items):
              A=input_items[0]
              Q=input_items[1]
              Sec=output_items[0]
              Sec[:]=A*np.exp(1j*Q)
              return len(Sec)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '32000'
  states: {}

connections:
- [E3TRadio_acumulador_truncado_ff_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_const_source_x_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', epy_block_0, '1']
- [epy_block_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', E3TRadio_acumulador_truncado_ff_0, '0']

metadata:
  file_format: 1
