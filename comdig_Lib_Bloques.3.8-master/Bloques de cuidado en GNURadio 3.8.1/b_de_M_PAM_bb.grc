options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Es el demodulador que hace juego con el b_M_PAM_bb. La salida es una senal binaria (PCM) pero de tipo Byte (osea, unos y ceros en formato Byte). Parametros usados: M- es el orden de la modulacion M-PAM.'
    generate_options: hb
    id: b_de_M_PAM_bb
    output_language: python
    title: b_de_M_PAM_bb
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Nbps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: M
  id: parameter
  parameters:
    label: M
    type: intx
    value: '4'
  states: {}
- name: SymbTune
  id: parameter
  parameters:
    label: SymbTune
    type: intx
    value: '2'
  states: {state: disabled}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: SymbTune
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: Nbps
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: Nbps
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: Nbps
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: e_unip_to_bipol
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de unipolar a bipolar una senal tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_unipolar to bipolar_bb',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):

              output_items[0][:] = input_items[0]*2-1
              return len(output_items[0])
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {state: disabled}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {state: disabled}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {state: disabled}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {state: disabled}
- name: pad_source_0_1
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_delay_0_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', e_unip_to_bipol, '0']
- [blocks_unpack_k_bits_bb_0_1_0, '0', pad_sink_0, '0']
- [blocks_unpack_k_bits_bb_0_1_0_0, '0', pad_sink_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_unpack_k_bits_bb_0_1_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_unpack_k_bits_bb_0_1_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [e_unip_to_bipol, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_delay_0_0_0, '0']
- [pad_source_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [pad_source_0_1, '0', blocks_unpacked_to_packed_xx_0_1, '0']

metadata:
  file_format: 1
