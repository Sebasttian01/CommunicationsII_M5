options:
  parameters:
    author: Homero Ortega
    category: '''[version_vieja]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'permite visualizar el diagrama de ojo. Parametros usados: Sps - muestras por simbolo; Vpico - amplitud pico de la señal'
    generate_options: hb
    id: b_eye_diagram_f
    output_language: python
    title: b_eye_diagram_f
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: Sps*256
  states: {}
- name: Delay
  id: parameter
  parameters:
    label: Delay
    type: intx
    value: '0'
  states: {}
- name: E3TRadio_vec_diagrama_ojo_f_0
  id: E3TRadio_vec_diagrama_ojo_f
  parameters:
    N: N
    Sps: Sps
    samp_rate: samp_rate
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    type: intx
    value: '8'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: '32000'
  states: {}

connections:
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', E3TRadio_vec_diagrama_ojo_f_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
