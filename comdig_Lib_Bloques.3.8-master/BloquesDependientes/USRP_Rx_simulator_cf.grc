options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    copyright: RadioGis UIS
    description: Recibe una senal pasobandas con frec de portadora Fc y con frec de muestreo samp_rate_in, la convierte Envolvente Compleja y hace una operacion similar a ADC, simplmente decimando la senal ADC_samp_factor veces
    generate_options: hb
    id: USRP_Rx_simulator_cf
    output_language: python
    title: USRP_Rx_simulator_cf
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_in/K
  states: {}
- name: Bandwidth
  id: parameter
  parameters:
    label: Bandwidth (Hz)
    value: '16000'
  states: {}
- name: Fc
  id: parameter
  parameters:
    label: frec de portadora
    value: '64000'
  states: {}
- name: K
  id: parameter
  parameters:
    label: ADC_samp_factor
    type: intx
    value: '8'
  states: {}
- name: b_downconverter_fc_0
  id: b_downconverter_fc
  parameters:
    BW: Bandwidth
    Fc: Fc
    samp_rate: samp_rate_in
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: K
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: samp_rate_in
  id: parameter
  parameters:
    label: samp_rate_in
    value: '32000'
  states: {}

connections:
- [b_downconverter_fc_0, '0', rational_resampler_xxx_0_0, '0']
- [pad_source_0_0, '0', b_downconverter_fc_0, '0']
- [rational_resampler_xxx_0_0, '0', pad_sink_0_0, '0']

metadata:
  file_format: 1
