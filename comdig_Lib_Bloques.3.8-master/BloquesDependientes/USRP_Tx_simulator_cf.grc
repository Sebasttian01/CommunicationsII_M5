options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    copyright: RadioGis UIS
    description: recibe una senal Envolvente Compleja con frec de muestreo samp_rate, realiza una operacion similar a DAC elevando DAC_resamp_factor veces la frec de muestreo y luego convierte la senal a pasobandas con una portadores de Fc Hertz. Si ve que la portadora no está bien definida, eleve DAC_resamp_factor (para senales digitales, se aconseja DAC_resamp_factor=Sps)
    generate_options: hb
    id: USRP_Tx_simulator_cf
    output_language: python
    title: USRP_Tx_simulator_cf
  states: {}

blocks:
- name: Fc
  id: parameter
  parameters:
    label: frec de portadora
    value: '64000'
  states: {}
- name: K
  id: parameter
  parameters:
    label: DAC_resamp_factor
    type: intx
    value: '8'
  states: {}
- name: b_upconverter_cf_0
  id: b_upconverter_cf
  parameters:
    Fc: Fc
    samp_rate: samp_rate*K
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: K
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '32000'
  states: {}

connections:
- [b_upconverter_cf_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', b_upconverter_cf_0, '0']

metadata:
  file_format: 1
