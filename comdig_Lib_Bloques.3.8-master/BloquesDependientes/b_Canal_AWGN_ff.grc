options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Este bloque es un simulador de un canal AWGN (Additive White Gaussian Noise). De modo que solo tiene tres características: suma ruido blanco a la señal,  restringe el ancho de banda e Introduce un retardo a la señal. Parametros: Ch_NodB - altura de la PSD del ruido blanco bandabase; samp_rate - frecuencia de muestreo de la señal; BW - ancho de banda bandabase, Ch_Toffset - retardo dado en muestraas que el canal introduce'
    generate_options: hb
    id: b_Canal_AWGN_ff
    output_language: python
    title: b_Canal_AWGN_ff
  states: {}

blocks:
- name: BW
  id: parameter
  parameters:
    label: BW (Hz)
    type: eng_float
    value: '1000'
  states: {}
- name: Ch_NodB
  id: parameter
  parameters:
    label: Ch. W.Noise (No in dB)
    type: eng_float
    value: '1000'
  states: {}
- name: Ch_Toffset
  id: parameter
  parameters:
    label: Channel Toffset
    type: intx
    value: '0'
  states: {}
- name: Note
  id: note
  parameters:
    note: Esta ramificacion de abajo es la que introduce las fluctuaciones en magnitud
  states: {}
- name: b_noise_dB_f_0
  id: b_noise_dB_f
  parameters:
    NodB: Ch_NodB
    samp_rate: '10000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Ch_Toffset
    type: float
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: BW/16
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: '1000'
  states: {}

connections:
- [b_noise_dB_f_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
