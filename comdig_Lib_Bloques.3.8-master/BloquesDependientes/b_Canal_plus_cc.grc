options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Este bloque es un simulador de un canal discreto, sencillo. La simplicidad de este canal esta en aplicar solo lo siguiente: ruido, desviacion de frecuencia, desviacion de angulo, fluctuaciones de magnitud, perdidas de propagacion. Para las fluctuaciones se supone que el umbral de amplitud de la senal que entra al canal es 1, como es el caso de los USRP. Parametros usados: samp_rate_Tx (Hz) es la frecuencia de muestreo del USRP transmisor;  Ch_Phoffset (Rad) permite programar el angulo de la portadora usada en transmision y la usada en recepcion; Ch_Toffset (muestras)  es el retardo que la senal sufre al pasar por el canal; No (dB) es el valor No (o PSD) dado en decibeles del ruido blanco del canal; Ch_Loss_dB (en dB de potencia) nivel de atenuacion que la senal transmitida sufre en el proceso de propagacion; Fluctuation - es el porcentaje de fluctuaciones en magnitud (un numero entero entre 0 y 100); Tfluct - es el periodo, dado en numero de muestras, en que ocurren las fluctuaciones'
    generate_options: hb
    id: b_Canal_plus_cc
    output_language: python
    title: b_Canal_plus_cc
  states: {}

blocks:
- name: Ch_Loss
  id: variable
  parameters:
    value: math.pow(10, Ch_Loss_dB/20.)
  states: {}
- name: SpS
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: Ch_Loss_dB
  id: parameter
  parameters:
    label: Ch_Loss_dB
    type: eng_float
    value: '10.'
  states: {}
- name: Ch_NodB
  id: parameter
  parameters:
    label: Ch. W.Noise (No in dB)
    type: intx
    value: '1000'
  states: {}
- name: Ch_Phoffset
  id: parameter
  parameters:
    label: Ch_Phoffset
    type: eng_float
    value: '0.'
  states: {}
- name: Ch_Toffset
  id: parameter
  parameters:
    label: Channel Toffset
    type: intx
    value: '0'
  states: {}
- name: E3TRadio_Zero_Order_Hold_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: T_fluct
  states: {}
- name: Fluctuacion
  id: parameter
  parameters:
    label: Fluctuacion (0-100)
    type: eng_float
    value: '10.0'
  states: {}
- name: Foffset
  id: parameter
  parameters:
    label: Freq offset (Hz)
    type: eng_float
    value: '0.'
  states: {}
- name: Note
  id: note
  parameters:
    note: Esta ramificacion de abajo es la que introduce las fluctuaciones en magnitud
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    type: intx
    value: '4'
  states: {state: disabled}
- name: T_fluct
  id: parameter
  parameters:
    label: T_fluct (muestras)
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: cmath.exp(1j * Ch_Phoffset)
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Fluctuacion/100.
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Foffset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: b_noise_dB_cc_0
  id: b_noise_dB_cc
  parameters:
    NodB: Ch_NodB
    samp_rate: samp_rate
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Ch_Toffset
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Ch_Loss+0j
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: Este bloque no se terminó nunca. Borrar
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Noise
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: Fluctuacion
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '1000'
  states: {}

connections:
- [E3TRadio_Zero_Order_Hold_0, '0', blocks_float_to_complex_0, '0']
- [E3TRadio_Zero_Order_Hold_0, '0', pad_sink_0_0_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_noise_source_x_0, '0', blocks_abs_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '2']
- [b_noise_dB_cc_0, '0', blocks_add_xx_0, '1']
- [b_noise_dB_cc_0, '0', pad_sink_0_0, '0']
- [blocks_abs_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_abs_xx_0_0, '0', E3TRadio_Zero_Order_Hold_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '3']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
