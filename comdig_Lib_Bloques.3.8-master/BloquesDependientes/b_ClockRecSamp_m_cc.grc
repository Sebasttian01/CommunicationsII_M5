options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander'
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Es un Clock o Timming Recovery con muestreo pero manual. Recibe una senal con modulacion digital basada en constelaciones, que llega sobremuestreada a la razon de Sps muestras por simbolo, proveniente de un canal, usted selecciona manualmente el mejor instante de muestreo con la ayuda de un diagrama de ojo que este bloque le brinda, selecciona el instante en que el ojo aparece mas abierto, finalmente el bloque produce la senal muestreada en el instante seleccionado por usted. En este sentido, este bloque es un decimador, pues por cada Sps muestras produce solo una. Entrega entonces una senal con una frecuencia de muestreo igual a la rata de simbolos. Parametros usados: samp_rate (Hz) - es la rata de muestreo de la senal recibida; Sps (muestras) - es el numero de muestras por simbolo que trae la senal entrante'
    generate_options: hb_qt_gui
    id: b_ClockRecSamp_m
    output_language: python
    title: b_ClockRecSamp_m
  states: {}

blocks:
- name: AlphaLineas
  id: variable
  parameters:
    value: '0.5'
  states: {state: disabled}
- name: Delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Mueva aqui para Centrar el Ojo
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps
    value: int(Sps/2)
  states: {state: disabled}
- name: Delay
  id: variable
  parameters:
    value: Sps-TimingDelay
  states: {}
- name: GrosorLineas
  id: variable
  parameters:
    value: '20'
  states: {state: disabled}
- name: N_eyes
  id: variable
  parameters:
    value: '2'
  states: {state: disabled}
- name: TimingDelay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    label: Seleccione instante en que ojo esta mas abierto
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '0'
  states: {}
- name: Ymax
  id: variable
  parameters:
    value: '2.'
  states: {state: disabled}
- name: Ymin
  id: variable
  parameters:
    value: '-2.'
  states: {state: disabled}
- name: E3TRadio_zero_order_hold2_cc_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: Sps
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '64'
  states: {}
- name: b_Eye_Diagram_c_0
  id: b_Eye_Diagram_c
  parameters:
    AlphaLineas: '0.5'
    Delay_i: '0'
    GrosorLineas: '20'
    N_eyes: '2'
    Samprate: samp_rate
    Sps: Sps
    Title: '"Eye Diagramm"'
    Ymax: '1.5'
    Ymin: '-1.5'
    gui_hint: 0,0,1,2
  states: {}
- name: b_sampler_cc_0
  id: b_sampler_cc
  parameters:
    DelayDiez: TimingDelay
    Sps: Sps
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Sps*2+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: Sps*3+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: Sps*3+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: Sps*4+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: Sps*4+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: Sps*5+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_2_0
  id: blocks_delay
  parameters:
    delay: Sps*5+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: Sps*6+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: Sps*9+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_3_0_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_3_0_0_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_3_0_1
  id: blocks_delay
  parameters:
    delay: Sps*9+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_3_1
  id: blocks_delay
  parameters:
    delay: Sps*6+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: Sps*7+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_4_0
  id: blocks_delay
  parameters:
    delay: Sps*7+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: Sps*8+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_5_0
  id: blocks_delay
  parameters:
    delay: Sps*8+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: Sps*1+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_6_0
  id: blocks_delay
  parameters:
    delay: Sps*1+Delay
    type: float
  states: {state: disabled}
- name: blocks_delay_0_7
  id: blocks_delay
  parameters:
    delay: Sps*2+Delay
    type: float
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    color1: '"black"'
    gui_hint: 1,1,1,1
    label1: Recibida
    label2: Muestreada
    name: ''
    nconnections: '2'
    size: '1024'
    type: complex
    width2: '2'
    xmax: '2.5'
    xmin: '-2.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: AlphaLineas
    alpha10: '1.'
    alpha2: AlphaLineas
    alpha3: AlphaLineas
    alpha4: AlphaLineas
    alpha5: AlphaLineas
    alpha6: AlphaLineas
    alpha7: AlphaLineas
    alpha8: AlphaLineas
    alpha9: AlphaLineas
    gui_hint: 0,0
    label1: ''
    label10: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    label7: ''
    label8: ''
    label9: ''
    marker10: '0'
    name: Parte Real
    nconnections: '10'
    size: int(Sps*N_eyes)
    srate: samp_rate
    type: float
    width1: GrosorLineas
    width2: GrosorLineas
    width3: GrosorLineas
    width4: GrosorLineas
    width5: GrosorLineas
    width6: GrosorLineas
    width7: GrosorLineas
    width8: GrosorLineas
    width9: GrosorLineas
    ymax: Ymax
    ymin: Ymin
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: AlphaLineas
    alpha10: '1.'
    alpha2: AlphaLineas
    alpha3: AlphaLineas
    alpha4: AlphaLineas
    alpha5: AlphaLineas
    alpha6: AlphaLineas
    alpha7: AlphaLineas
    alpha8: AlphaLineas
    alpha9: AlphaLineas
    gui_hint: 0,1
    label1: ''
    label10: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    label7: ''
    label8: ''
    label9: ''
    marker10: '0'
    name: Parte Imaginaria
    nconnections: '10'
    size: int(Sps*N_eyes)
    srate: samp_rate
    type: float
    width1: GrosorLineas
    width2: GrosorLineas
    width3: GrosorLineas
    width4: GrosorLineas
    width5: GrosorLineas
    width6: GrosorLineas
    width7: GrosorLineas
    width8: GrosorLineas
    width9: GrosorLineas
    ymax: Ymax
    ymin: Ymin
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '64'
  states: {}

connections:
- [E3TRadio_zero_order_hold2_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [b_sampler_cc_0, '0', b_Eye_Diagram_c_0, '0']
- [b_sampler_cc_0, '0', blocks_complex_to_float_0, '0']
- [b_sampler_cc_0, '1', E3TRadio_zero_order_hold2_cc_0, '0']
- [b_sampler_cc_0, '1', pad_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_delay_0_3_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_delay_0_3_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_1, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_2, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_3, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_3_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_4, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_5, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_6, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_1_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_2_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_3_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_3_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_4_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_5_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_6_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_7, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '2']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_0_0, '3']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0_0_0_0, '3']
- [blocks_delay_0_2, '0', qtgui_time_sink_x_0_0_0, '4']
- [blocks_delay_0_2_0, '0', qtgui_time_sink_x_0_0_0_0, '4']
- [blocks_delay_0_3, '0', qtgui_time_sink_x_0_0_0, '5']
- [blocks_delay_0_3_0, '0', qtgui_time_sink_x_0_0_0, '8']
- [blocks_delay_0_3_0_0, '0', qtgui_time_sink_x_0_0_0, '9']
- [blocks_delay_0_3_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '9']
- [blocks_delay_0_3_0_1, '0', qtgui_time_sink_x_0_0_0_0, '8']
- [blocks_delay_0_3_1, '0', qtgui_time_sink_x_0_0_0_0, '5']
- [blocks_delay_0_4, '0', qtgui_time_sink_x_0_0_0, '6']
- [blocks_delay_0_4_0, '0', qtgui_time_sink_x_0_0_0_0, '6']
- [blocks_delay_0_5, '0', qtgui_time_sink_x_0_0_0, '7']
- [blocks_delay_0_5_0, '0', qtgui_time_sink_x_0_0_0_0, '7']
- [blocks_delay_0_6, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_delay_0_6_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_delay_0_7, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [pad_source_0, '0', b_Eye_Diagram_c_0, '1']
- [pad_source_0, '0', b_sampler_cc_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0_0, '0']
- [pad_source_0, '0', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
