options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[en_prueba]'''
    description: 'Permite sintonizar manualmente el canal al punto de entregar la senal correctamente muestreada. Parametros usados: samp_rate (Hz) la frecuencia de muestreo de la senal entrante; sps (muestras) numero de muestras por simbolo en la senal entrante; Delay Tuning (muestras) el retrazo que se introduce a la senal antes de aplicarle el muestreo; PhiTuning (Rad) angulo usado para corregir la desviacion de angulo producida por el canal; F_Tuning (Hz) correccion de la desviacion de frecuencias; Nscope (muestras) numero de bits a mostrar en el scope'
    generate_options: hb_qt_gui
    id: b_QT_tunner_sampler
    output_language: python
    run: run_stop
    title: b_QT_tunner_sampler
  states: {}

blocks:
- name: DelayTuning
  id: variable_qtgui_range
  parameters:
    gui_hint: pestana@3:0,0,1,1
    label: 'Retardo antes de muestreo '
    rangeType: int
    start: '0'
    step: '1'
    stop: sps-1
    value: '0'
  states: {}
- name: F_Tuning
  id: variable_qtgui_range
  parameters:
    gui_hint: pestana@3:1,0,1,1
    label: Rx Frequency tunining
    start: '0'
    step: 10./1000.
    stop: '10.'
    value: '0'
  states: {}
- name: Foffset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Offset de frec.
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0'
  states: {}
- name: Kruido
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Nivel del Ruido
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.01'
  states: {}
- name: Nscope_span
  id: variable
  parameters:
    value: '24'
  states: {}
- name: PhiTuning
  id: variable_qtgui_range
  parameters:
    gui_hint: pestana@3:0,1,1,1
    label: Rx angle tunining
    start: '0'
    step: (numpy.pi)*2/200
    stop: (numpy.pi)*2
    value: '0'
  states: {}
- name: phi
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Angulo
    start: '-numpy.pi'
    step: numpy.pi/100.
    stop: numpy.pi
    value: '0.'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: b_sampler_cc_0
  id: b_sampler_cc
  parameters:
    DelayDiez: '0'
    Sps: sps
  states: {}
- name: b_tunner_0
  id: b_tunner
  parameters:
    Ganancia_ajuste_dB: '0'
    NDelay: DelayTuning
    fdesv: '-F_Tuning'
    phi: PhiTuning
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import random
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pestana
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,1,4
    label0: Tiempo
    label1: Constelacion
    label2: Espectro
    label3: Tunner
    num_tabs: '4'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: pestana@3:2,0,1,1
    label1: Rx
    name: '"Rx canal"'
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '0.2'
    xmin: '-0.2'
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: pestana@3:2,1,1,1
    label1: Rx
    name: '"Rx sampled"'
    size: '1024'
    type: complex
    xmax: '0.2'
    xmin: '-0.2'
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_1_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: pestana@3:3,0,1,2
    label1: Rx I
    label2: Rx Q
    label3: ''
    label4: ''
    name: '"Rx Sample Tunning"'
    nconnections: '2'
    size: Nscope_span*sps
    srate: samp_rate
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}

connections:
- [b_sampler_cc_0, '0', qtgui_const_sink_x_0_0_0, '1']
- [b_sampler_cc_0, '0', qtgui_time_sink_x_1_1_0_0_0, '1']
- [b_sampler_cc_0, '1', pad_sink_0, '0']
- [b_sampler_cc_0, '1', qtgui_const_sink_x_0_0_0_0, '0']
- [b_tunner_0, '0', b_sampler_cc_0, '0']
- [b_tunner_0, '0', qtgui_time_sink_x_1_1_0_0_0, '0']
- [pad_source_0, '0', b_tunner_0, '0']
- [pad_source_0, '0', qtgui_const_sink_x_0_0_0, '0']

metadata:
  file_format: 1
