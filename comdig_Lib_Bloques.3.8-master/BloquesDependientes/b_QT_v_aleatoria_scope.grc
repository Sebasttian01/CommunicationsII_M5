options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    description: 'Some parameters of a random variable can visualized, like: the mean, the RMS value, the mean power, the PSD, the time signal. Parameters used: samp_rate - the sample rate of the signal; N_time - the number of time samples to be shown; N_frec- the number of frequency pointss to be shown '
    generate_options: hb_qt_gui
    id: b_v_aleatoria_scope_f
    output_language: python
    title: b_v_aleatoria_scope_f
  states: {}

blocks:
- name: Mean_reset
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,3,1,1
    label: Push here to restart averaging procces
    pressed: '0'
    released: '1'
    type: int
    value: '1'
  states: {}
- name: E3TRadio_mean_meter_0
  id: E3TRadio_mean_meter
  parameters:
    reset: Mean_reset
  states: {}
- name: E3TRadio_mean_meter_0_0
  id: E3TRadio_mean_meter
  parameters:
    reset: Mean_reset
  states: {}
- name: N_frec
  id: parameter
  parameters:
    label: N_frec
    value: '2014'
  states: {}
- name: N_time
  id: parameter
  parameters:
    label: N_time
    value: '2014'
  states: {}
- name: V_p
  id: parameter
  parameters:
    label: Valor pico
    value: '2014'
  states: {}
- name: b_PSD_0
  id: b_PSD
  parameters:
    Ensayos: '1000000'
    N: N_frec
    Titulo: '''PSD ( linear scale)'''
    Ymax: 1./samp_rate
    gui_hint: 2,0,1,2
    samp_rate: '22000'
  states: {}
- name: b_QT_autocorrel_0
  id: b_QT_autocorrel
  parameters:
    Ensayos: '1000000'
    N: N_frec
    Ymax: '4e-7'
    gui_hint: 2,2,1,2
    samp_rate_audio: samp_rate
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: In
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: N_frec
    gui_hint: 2,2,1,2
    label1: '.'
    name: '"PSD (dB/Hz)"'
    showports: 'True'
    type: float
    width1: '3'
    ymax: math.log10(samp_rate)
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '1024'
    gui_hint: 1,2,1,2
    label1: '.'
    name: '"histogram"'
    size: '1024'
    type: float
    update_time: '1'
    width1: '2'
    xmax: V_p
    xmin: '-V_p'
  states: {}
- name: qtgui_number_sink_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,1
    label1: The mean
    max: '2'
    min: '-2'
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,1,1,1
    label1: Mean square (Mean Power)
    max: '2'
    min: '-2'
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,2,1,1
    label1: VRMS instantaneous
    max: '2'
    min: '-2'
    name: ''
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,2
    label1: '.'
    name: '"signal in time"'
    size: N_time
    srate: samp_rate
    type: float
    width1: '3'
    ymax: V_p
    ymin: '-V_p'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Fmuestreo
    value: '22000'
  states: {}

connections:
- [E3TRadio_mean_meter_0, '0', qtgui_number_sink_0_0_0_0_0, '0']
- [E3TRadio_mean_meter_0_0, '0', qtgui_number_sink_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', E3TRadio_mean_meter_0_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0_0_0_0_0_0_0, '0']
- [pad_source_2, '0', E3TRadio_mean_meter_0, '0']
- [pad_source_2, '0', b_PSD_0, '0']
- [pad_source_2, '0', b_QT_autocorrel_0, '0']
- [pad_source_2, '0', blocks_multiply_xx_0, '0']
- [pad_source_2, '0', blocks_multiply_xx_0, '1']
- [pad_source_2, '0', blocks_rms_xx_0, '0']
- [pad_source_2, '0', qtgui_histogram_sink_x_0, '0']
- [pad_source_2, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
