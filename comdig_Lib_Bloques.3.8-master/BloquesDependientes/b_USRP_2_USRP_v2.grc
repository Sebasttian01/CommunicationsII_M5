options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Este bloque es el simulador de un canal inalambrico que incluye 2 USRPs, uno en la parte transmisora y otro en la receptora. Se puede usar cuando no se tengan USRP fisicos a la mano. Parametros usados: samp_rate_Tx (Hz) es la frecuencia de muestreo del USRP transmisor; Bandwidth_Tx  (Hz) ancho de banda programado en el USRP transmisor; Center freq Tx (Hz) frecuencia central del USRP Transmisor; samp_rate_Rx, Bandwidth_Rx, Center freq Rx  son equivalentes a los anteriores pero para el USRP receptor;  Toffset (numero de muestras de offset. como la rata de muestras de la senal entrante puede ser diferente a la saliente, en este caso se toman de la senal entrante) permtite programar un tiempo de retardo de la senal en propagacion;  Phoffset (Rad) permite programar una desviacion entre el angulo de la portadora usada en transmision y la usada en recepcion; No (dB) es el valor No (o PSD) dado en decibeles del ruido blanco del canal; Katt (en dB de potencia) nivel de atenuacion que la senal transmitida sufre en el proceso de propagacion. '
    generate_options: hb
    id: b_USRP_2_USRP_v2
    output_language: python
    title: b_USRP_2_USRP_v2
  states: {}

blocks:
- name: B_Rxx
  id: variable
  parameters:
    value: (Rx_B>0)*Rx_B+(Rx_B==0)*Rx__samp_rate
  states: {}
- name: B_Txx
  id: variable
  parameters:
    value: (Tx_B>0)*Tx_B+(Tx_B==0)*Tx__samp_rate
  states: {}
- name: Bmin
  id: variable
  parameters:
    value: min(B_Txx, B_Rxx)
  states: {}
- name: Foffset
  id: variable
  parameters:
    value: Tx_Fc-Rx_Fc
  states: {}
- name: Gain_Rx
  id: variable
  parameters:
    value: math.pow(10, Rx_Gain_dB/20.)
  states: {}
- name: Gain_Tx_Loss
  id: variable
  parameters:
    value: math.pow(10, Gain_Tx_Loss_dB/20.)
  states: {}
- name: Gain_Tx_Loss_dB
  id: variable
  parameters:
    value: Tx_Gain_dB  - Ch_Loss_dB
  states: {}
- name: Ch_Loss_dB
  id: parameter
  parameters:
    label: Channel Attenuation (dB)
    type: eng_float
    value: '10.'
  states: {}
- name: Ch_NodB
  id: parameter
  parameters:
    label: Channel White Noise (No in dB)
    type: intx
    value: '1000'
  states: {}
- name: Ch_Phoffset
  id: parameter
  parameters:
    label: Channel Angle Offset
    type: eng_float
    value: (numpy.pi)*2*random.random()
  states: {}
- name: Ch_Toffset
  id: parameter
  parameters:
    label: Channel Toffset
    type: intx
    value: '5'
  states: {}
- name: Note
  id: note
  parameters:
    note: 'Por mejorar:  1) no se tiene en cuenta el filtrado 2) si la frecuencia de muestreo del transmisor y receptor son diferentes saldria error, pues los elementos despues del rational resampler no estan ajustados a la frecuencia de ese bloque  3) El hardware y software interno del USR tienen limitaciones que no son tenidas en cuenta aqui como: los amplificadores de los USRP tienen valores limitados 2) El cuantizador del tiene un rango dinamico definido, el decimador esta limitado a ciertos coeficientes. Una mejora, deberia incluir un simulador de los bloques que tienen que ver con esos parametros.'
  states: {}
- name: Rx_B
  id: parameter
  parameters:
    label: Rx Bandwidth (Hz)
    type: eng_float
    value: '1000'
  states: {}
- name: Rx_Fc
  id: parameter
  parameters:
    label: Rx Center Freq (Hz)
    type: eng_float
    value: '200000000'
  states: {}
- name: Rx_Gain_dB
  id: parameter
  parameters:
    label: Rx_Gain_dB
    type: eng_float
    value: '10.'
  states: {}
- name: Rx__samp_rate
  id: parameter
  parameters:
    label: Rx_samp_rate (int)
    type: intx
    value: '1000'
  states: {}
- name: Tx_B
  id: parameter
  parameters:
    label: Tx_Bandwidth (Hz)
    type: eng_float
    value: '1000'
  states: {}
- name: Tx_Fc
  id: parameter
  parameters:
    label: Tx Center Freq(Hz)
    type: eng_float
    value: '200000000'
  states: {}
- name: Tx_Gain_dB
  id: parameter
  parameters:
    label: Tx_Gain_dB
    type: eng_float
    value: '10.'
  states: {}
- name: Tx__samp_rate
  id: parameter
  parameters:
    label: Tx_samp_rate (int)
    type: intx
    value: '1000'
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: cmath.exp(1j * Ch_Phoffset)
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Foffset
    offset: '0'
    phase: '0'
    samp_rate: Rx__samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: b_noise_dB_cc_0
  id: b_noise_dB_cc
  parameters:
    NodB: Ch_NodB
    samp_rate: '10000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Ch_Toffset
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Gain_Tx_Loss+0j
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Gain_Rx+0j
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Noise
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(Tx__samp_rate)
    interp: int(Rx__samp_rate)
    taps: ''
    type: ccc
  states: {state: disabled}

connections:
- [analog_const_source_x_1_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [b_noise_dB_cc_0, '0', blocks_add_xx_0, '0']
- [b_noise_dB_cc_0, '0', pad_sink_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
