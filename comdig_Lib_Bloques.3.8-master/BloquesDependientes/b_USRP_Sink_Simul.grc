options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Es un simulador del bloque USRP_Sink con el hardware tipo USRP 2920. Entrega una senal pasobandas, con una frecuencia de muestreo que se calcula asi: samp_rate_o=(Center_Freq+samp_rate/2)*8'
    generate_options: hb
    id: b_USRP_Sink_simul_f
    output_language: python
    title: b_USRP_Sink_simul_f
  states: {}

blocks:
- name: Samp_Rate_o
  id: variable
  parameters:
    value: int((Center_Freq+Samp_Rate/2)*8)
  states: {}
- name: Bandwidth
  id: parameter
  parameters:
    label: 'Ch0: Bandwidth (Hz)'
    value: '0'
  states: {}
- name: Center_Freq
  id: parameter
  parameters:
    label: 'Ch0: Center_Freq'
    value: '50000000'
  states: {}
- name: Gain_Value_dB
  id: parameter
  parameters:
    label: 'Ch0: Gain_Value (dB)'
    value: '0'
  states: {}
- name: Lo_que_falta
  id: note
  parameters:
    note: poner amplificador, poner rango dinamico
  states: {}
- name: Samp_Rate
  id: parameter
  parameters:
    label: Samp Rate (Sps)
    value: '200000'
  states: {}
- name: b_upconverter_cf_0
  id: b_upconverter_cf
  parameters:
    Fc: Center_Freq
    samp_rate: Samp_Rate_o
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Samp_Rate
    interp: Samp_Rate_o
    taps: ''
    type: ccc
  states: {}
- name: samp_rate_o
  id: parameter
  parameters:
    label: samp_rate_o
    type: intx
    value: 50000000+200000
  states: {state: disabled}
- name: tag_name
  id: parameter
  parameters:
    label: TSB tag name
    value: '"    "'
  states: {}

connections:
- [b_upconverter_cf_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', b_upconverter_cf_0, '0']

metadata:
  file_format: 1
