options:
  parameters:
    author: Homoero Ortega Boada
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb
    id: b_USRP_Sourc_simul_f
    output_language: python
    title: b_USRP_Sourc_simul_f
  states: {}

blocks:
- name: Bandwidth
  id: parameter
  parameters:
    label: Bandwidth (Hz)
    value: '0'
  states: {}
- name: Center_Freq
  id: parameter
  parameters:
    label: Center_Freq
    value: '50000000'
  states: {}
- name: Gain_Value_dB
  id: parameter
  parameters:
    label: Gain_Value (dB)
    value: '0'
  states: {}
- name: Lo_que_falta
  id: note
  parameters:
    note: poner amplificador, poner rango dinamico; condicion para B=0
  states: {}
- name: b_downconverter_fc_0
  id: b_downconverter_fc
  parameters:
    BW: samp_rate/2
    Fc: Center_Freq
    samp_rate: samp_rate_rf
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate_rf
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '200000'
  states: {}
- name: samp_rate_rf
  id: parameter
  parameters:
    label: samp_rate_rf
    type: intx
    value: 50000000+200000
  states: {}

connections:
- [b_downconverter_fc_0, '0', rational_resampler_xxx_0_0, '0']
- [pad_source_0_0, '0', b_downconverter_fc_0, '0']
- [rational_resampler_xxx_0_0, '0', pad_sink_0_0, '0']

metadata:
  file_format: 1
