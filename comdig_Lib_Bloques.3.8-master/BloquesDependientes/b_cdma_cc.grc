options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[en_prueba]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb
    id: b_cdma_cc
    output_language: python
    title: b_cdma
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '8'
  states: {}
- name: b_ds_spreadspect_cc_0
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c0
  states: {}
- name: b_ds_spreadspect_cc_0_0
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c1
  states: {}
- name: b_ds_spreadspect_cc_0_0_0
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c2
  states: {}
- name: b_ds_spreadspect_cc_0_0_1
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c3
  states: {}
- name: b_ds_spreadspect_cc_0_0_2
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c4
  states: {}
- name: b_ds_spreadspect_cc_0_0_3
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c5
  states: {}
- name: b_ds_spreadspect_cc_0_0_4
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c6
  states: {}
- name: b_ds_spreadspect_cc_0_0_5
  id: b_ds_spreadspect_cc
  parameters:
    SF: '8'
    codigo: c7
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {}
- name: c0
  id: parameter
  parameters:
    label: c0
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c1
  id: parameter
  parameters:
    label: c1
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c2
  id: parameter
  parameters:
    label: c2
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c3
  id: parameter
  parameters:
    label: c3
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c4
  id: parameter
  parameters:
    label: c4
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c5
  id: parameter
  parameters:
    label: c5
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c6
  id: parameter
  parameters:
    label: c6
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c7
  id: parameter
  parameters:
    label: c7
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: info
  id: pad_sink
  parameters:
    label: infode us1
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: cod de us1
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: in2
    type: complex
  states: {}
- name: pad_source_3
  id: pad_source
  parameters:
    label: in3
    type: complex
  states: {}
- name: pad_source_4
  id: pad_source
  parameters:
    label: in4
    type: complex
  states: {}
- name: pad_source_5
  id: pad_source
  parameters:
    label: in5
    type: complex
  states: {}
- name: pad_source_6
  id: pad_source
  parameters:
    label: in6
    type: complex
  states: {}
- name: pad_source_7
  id: pad_source
  parameters:
    label: in7
    type: complex
  states: {}

connections:
- [b_ds_spreadspect_cc_0, '0', blocks_add_xx_0, '0']
- [b_ds_spreadspect_cc_0_0, '0', blocks_add_xx_0, '1']
- [b_ds_spreadspect_cc_0_0, '1', pad_sink_0_0, '0']
- [b_ds_spreadspect_cc_0_0, '2', info, '0']
- [b_ds_spreadspect_cc_0_0_0, '0', blocks_add_xx_0, '2']
- [b_ds_spreadspect_cc_0_0_1, '0', blocks_add_xx_0, '3']
- [b_ds_spreadspect_cc_0_0_2, '0', blocks_add_xx_0, '4']
- [b_ds_spreadspect_cc_0_0_3, '0', blocks_add_xx_0, '5']
- [b_ds_spreadspect_cc_0_0_4, '0', blocks_add_xx_0, '6']
- [b_ds_spreadspect_cc_0_0_5, '0', blocks_add_xx_0, '7']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', b_ds_spreadspect_cc_0, '0']
- [pad_source_1, '0', b_ds_spreadspect_cc_0_0, '0']
- [pad_source_2, '0', b_ds_spreadspect_cc_0_0_0, '0']
- [pad_source_3, '0', b_ds_spreadspect_cc_0_0_1, '0']
- [pad_source_4, '0', b_ds_spreadspect_cc_0_0_2, '0']
- [pad_source_5, '0', b_ds_spreadspect_cc_0_0_3, '0']
- [pad_source_6, '0', b_ds_spreadspect_cc_0_0_4, '0']
- [pad_source_7, '0', b_ds_spreadspect_cc_0_0_5, '0']

metadata:
  file_format: 1
