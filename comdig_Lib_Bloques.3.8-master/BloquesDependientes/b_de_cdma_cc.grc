options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb
    id: b_de_cdma_cc
    output_language: python
    title: b_de_cdma_cc
  states: {}

blocks:
- name: g
  id: variable
  parameters:
    value: '8'
  states: {}
- name: ChipsSysDelay
  id: parameter
  parameters:
    label: ChipsSysDelay
    type: intx
    value: '0'
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '8'
  states: {}
- name: b_de_ds_spreadspect_cc_0
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c0
  states: {}
- name: b_de_ds_spreadspect_cc_0_0
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c1
  states: {}
- name: b_de_ds_spreadspect_cc_0_2
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c7
  states: {}
- name: b_de_ds_spreadspect_cc_0_3
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c6
  states: {}
- name: b_de_ds_spreadspect_cc_0_4
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c5
  states: {}
- name: b_de_ds_spreadspect_cc_0_5
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c4
  states: {}
- name: b_de_ds_spreadspect_cc_0_6
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c3
  states: {}
- name: b_de_ds_spreadspect_cc_0_7
  id: b_de_ds_spreadspect_cc
  parameters:
    ChipsSysDelay: ChipsSysDelay
    SF: SF
    codigo: c2
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '12'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '16'
    type: complex
  states: {}
- name: c0
  id: parameter
  parameters:
    label: c0
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c1
  id: parameter
  parameters:
    label: c1
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c2
  id: parameter
  parameters:
    label: c2
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c3
  id: parameter
  parameters:
    label: c3
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c4
  id: parameter
  parameters:
    label: c4
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c5
  id: parameter
  parameters:
    label: c5
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c6
  id: parameter
  parameters:
    label: c6
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: c7
  id: parameter
  parameters:
    label: c7
    value: (0+0j,0+0j,0+0j)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out0
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out1
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out2
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: out3
    type: complex
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: out4
    type: complex
  states: {}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: out5
    type: complex
  states: {}
- name: pad_sink_6
  id: pad_sink
  parameters:
    label: out6
    type: complex
  states: {}
- name: pad_sink_7
  id: pad_sink
  parameters:
    label: out7
    type: complex
  states: {}
- name: pad_sink_8
  id: pad_sink
  parameters:
    label: diez
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_9
  id: pad_sink
  parameters:
    label: acum
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_9_0
  id: pad_sink
  parameters:
    label: mult
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_9_1
  id: pad_sink
  parameters:
    label: cod
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [b_de_ds_spreadspect_cc_0, '0', blocks_null_sink_0, '2']
- [b_de_ds_spreadspect_cc_0, '1', blocks_null_sink_0, '3']
- [b_de_ds_spreadspect_cc_0, '2', blocks_null_sink_0, '0']
- [b_de_ds_spreadspect_cc_0, '3', blocks_null_sink_0, '1']
- [b_de_ds_spreadspect_cc_0, '4', pad_sink_0, '0']
- [b_de_ds_spreadspect_cc_0_0, '0', pad_sink_9, '0']
- [b_de_ds_spreadspect_cc_0_0, '1', pad_sink_9_1, '0']
- [b_de_ds_spreadspect_cc_0_0, '2', pad_sink_8, '0']
- [b_de_ds_spreadspect_cc_0_0, '3', pad_sink_9_0, '0']
- [b_de_ds_spreadspect_cc_0_0, '4', pad_sink_1, '0']
- [b_de_ds_spreadspect_cc_0_2, '0', blocks_null_sink_1, '14']
- [b_de_ds_spreadspect_cc_0_2, '1', blocks_null_sink_1, '15']
- [b_de_ds_spreadspect_cc_0_2, '2', blocks_null_sink_1, '12']
- [b_de_ds_spreadspect_cc_0_2, '3', blocks_null_sink_1, '13']
- [b_de_ds_spreadspect_cc_0_2, '4', pad_sink_7, '0']
- [b_de_ds_spreadspect_cc_0_3, '0', blocks_null_sink_1, '10']
- [b_de_ds_spreadspect_cc_0_3, '1', blocks_null_sink_1, '11']
- [b_de_ds_spreadspect_cc_0_3, '2', blocks_null_sink_1, '8']
- [b_de_ds_spreadspect_cc_0_3, '3', blocks_null_sink_1, '9']
- [b_de_ds_spreadspect_cc_0_3, '4', pad_sink_6, '0']
- [b_de_ds_spreadspect_cc_0_4, '0', blocks_null_sink_1, '6']
- [b_de_ds_spreadspect_cc_0_4, '1', blocks_null_sink_1, '7']
- [b_de_ds_spreadspect_cc_0_4, '2', blocks_null_sink_1, '4']
- [b_de_ds_spreadspect_cc_0_4, '3', blocks_null_sink_1, '5']
- [b_de_ds_spreadspect_cc_0_4, '4', pad_sink_5, '0']
- [b_de_ds_spreadspect_cc_0_5, '0', blocks_null_sink_1, '2']
- [b_de_ds_spreadspect_cc_0_5, '1', blocks_null_sink_1, '3']
- [b_de_ds_spreadspect_cc_0_5, '2', blocks_null_sink_1, '0']
- [b_de_ds_spreadspect_cc_0_5, '3', blocks_null_sink_1, '1']
- [b_de_ds_spreadspect_cc_0_5, '4', pad_sink_4, '0']
- [b_de_ds_spreadspect_cc_0_6, '0', blocks_null_sink_0, '10']
- [b_de_ds_spreadspect_cc_0_6, '1', blocks_null_sink_0, '11']
- [b_de_ds_spreadspect_cc_0_6, '2', blocks_null_sink_0, '8']
- [b_de_ds_spreadspect_cc_0_6, '3', blocks_null_sink_0, '9']
- [b_de_ds_spreadspect_cc_0_6, '4', pad_sink_3, '0']
- [b_de_ds_spreadspect_cc_0_7, '0', blocks_null_sink_0, '6']
- [b_de_ds_spreadspect_cc_0_7, '1', blocks_null_sink_0, '7']
- [b_de_ds_spreadspect_cc_0_7, '2', blocks_null_sink_0, '4']
- [b_de_ds_spreadspect_cc_0_7, '3', blocks_null_sink_0, '5']
- [b_de_ds_spreadspect_cc_0_7, '4', pad_sink_2, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0_0, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0_2, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0_3, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0_4, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0_5, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0_6, '0']
- [pad_source_0, '0', b_de_ds_spreadspect_cc_0_7, '0']

metadata:
  file_format: 1
