options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'multiplica la entrada dsss por codigo para producir una senal inversa al Direc Sequence Spread Spectrum (DSSS). El cuidado que hay que tener es que el Spreading Factor (SF) se cuadra desde afuera, para la cual la senal de la informacion debe entrar con un sobremuestreo SF. Los parametros usados son: codigo - es el codigo que se usara para producir la senal DSSS; CodeDelay (muestras) permite introducir un retrazo en la aplicacion del codigo lo cual es util para tener en cuenta que la senal a des ensanchar puede llegar con un retrazo'
    generate_options: hb
    id: b_de_ds_spreadspect_cc
    output_language: python
    title: b_de_ds_spreadspect_cc
  states: {}

blocks:
- name: AccDelay
  id: variable
  parameters:
    value: int((float(ChipsSysDelay)/SF-ChipsSysDelay/SF)*SF)
  states: {}
- name: SamplerDelay
  id: variable
  parameters:
    value: ((AccDelay+SF-1)/SF-int((AccDelay+SF-1)/SF))*SF
  states: {}
- name: ChipsSysDelay
  id: parameter
  parameters:
    label: ChipsSysDelay
    value: '0'
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '8'
  states: {}
- name: b_accum_cc_0
  id: b_accum_cc
  parameters:
    M: AccDelay
    N: SF
  states: {}
- name: b_sampler_cc_0
  id: b_sampler_cc
  parameters:
    DelayDiez: SamplerDelay
    Sps: SF
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: ChipsSysDelay
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./SF
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: codigo
  states: {}
- name: codigo
  id: parameter
  parameters:
    label: codigo
    value: (1,1,1,1,1,1,1,1)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: diezm
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_1_0
  id: pad_sink
  parameters:
    label: multiplicador
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_1_0_0
  id: pad_sink
  parameters:
    label: Accum
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_1_1
  id: pad_sink
  parameters:
    label: cod
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [b_accum_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [b_sampler_cc_0, '0', pad_sink_0_1, '0']
- [b_sampler_cc_0, '1', pad_sink_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', pad_sink_0_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', b_sampler_cc_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0_1_0_0, '0']
- [blocks_multiply_xx_0, '0', b_accum_cc_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0_1_0, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
