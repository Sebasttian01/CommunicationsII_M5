options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: Permite demodular una senal BPSK de manera pedagogica para qeue los estudiantes comprendan el proceso interno
    generate_options: hb
    id: b_DeMod_BPSK
    output_language: python
    title: b_DeMod_BPSK
  states: {}

blocks:
- name: DelayAcc
  id: parameter
  parameters:
    label: Delay of Accum.
    type: intx
    value: '2'
  states: {}
- name: DelayDiez
  id: parameter
  parameters:
    label: Delay in Decimater
    type: intx
    value: '4'
  states: {}
- name: E3TRadio_acumulador_truncado_ff_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: DelayAcc
    N: Sps
  states: {}
- name: E3TRadio_decisor_ff_0
  id: E3TRadio_decisor_ff
  parameters:
    Umbral: '0.'
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Samp per symb
    type: intx
    value: '8'
  states: {}
- name: b_sampler_0
  id: b_sampler
  parameters:
    DelayDiez: DelayDiez
    Sps: Sps
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: sampler
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: Oppenh
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: Acum
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_6
  id: pad_sink
  parameters:
    label: ReInput
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_acumulador_truncado_ff_0, '0', b_sampler_0, '0']
- [E3TRadio_acumulador_truncado_ff_0, '0', pad_sink_4, '0']
- [E3TRadio_decisor_ff_0, '0', pad_sink_0, '0']
- [b_sampler_0, '0', E3TRadio_decisor_ff_0, '0']
- [b_sampler_0, '0', pad_sink_1, '0']
- [b_sampler_0, '1', pad_sink_3, '0']
- [blocks_complex_to_float_0, '0', E3TRadio_acumulador_truncado_ff_0, '0']
- [blocks_complex_to_float_0, '0', pad_sink_6, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
