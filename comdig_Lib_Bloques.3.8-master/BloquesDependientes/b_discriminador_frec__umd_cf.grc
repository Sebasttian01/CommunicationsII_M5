options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Se refierea al Discriminador de frecuencias documentado en: https://user.eng.umd.edu/~tretter/commlab/c6713slides/ch8.pdf, pag 14'
    generate_options: hb
    id: b_discriminador_frec_umd_cf
    output_language: python
    title: b_discriminador_frec_umd_cf
  states: {}

blocks:
- name: b_derivador_ff_0
  id: b_derivador_ff
  parameters:
    F_muestreo: '1'
  states: {}
- name: b_derivador_ff_0_0
  id: b_derivador_ff
  parameters:
    F_muestreo: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [b_derivador_ff_0, '0', blocks_multiply_xx_1, '1']
- [b_derivador_ff_0_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_complex_to_float_0, '0', b_derivador_ff_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_complex_to_float_0, '1', b_derivador_ff_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', pad_sink_1, '0']
- [blocks_multiply_xx_1, '0', blocks_sub_xx_1, '1']
- [blocks_multiply_xx_1_0, '0', blocks_sub_xx_1, '0']
- [blocks_sub_xx_1, '0', blocks_divide_xx_0, '0']
- [pad_source_0_0, '0', blocks_complex_to_float_0, '0']
- [pad_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
