options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: Se refierea al Discriminador de frecuencias que en el libro de Haykin, capitulo 2.7 esta representado como H1(f). BW es el ancho de banda de la senal entrante.
    generate_options: hb
    id: b_discriminador_frec_cf
    output_language: python
    title: b_discriminador_frec_cf
  states: {}

blocks:
- name: pendiente
  id: variable
  parameters:
    value: '1.'
  states: {}
- name: BW
  id: parameter
  parameters:
    label: Ancho de banda
    type: eng_float
    value: '1000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: BW*2*math.pi*1.j
    type: complex
  states: {}
- name: b_derivador_cc_0
  id: b_derivador_cc
  parameters:
    F_muestreo: '1.'
  states: {}
- name: b_derivador_cc_0_0
  id: b_derivador_cc
  parameters:
    F_muestreo: '1.'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pendiente
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pendiente
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [b_derivador_cc_0, '0', blocks_add_xx_0, '0']
- [b_derivador_cc_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_sub_xx_0_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', b_derivador_cc_0, '0']
- [pad_source_0, '0', b_derivador_cc_0_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
