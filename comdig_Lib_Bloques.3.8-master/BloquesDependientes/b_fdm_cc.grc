options:
  parameters:
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb
    id: b_fdm_cc
    output_language: python
    title: b_fdm_cc
  states: {}

blocks:
- name: AnchoCanales
  id: variable
  parameters:
    value: samp_rate/(2*N)
  states: {}
- name: Bps
  id: variable
  parameters:
    value: int(math.log(len(Constelacion),2))
  states: {}
- name: Constelacion
  id: variable
  parameters:
    value: '[1+.0j,-1+.0j, .0+1j,0 -1j ]'
  states: {}
- name: Fguarda
  id: variable
  parameters:
    value: AnchoCanales
  states: {}
- name: N
  id: variable
  parameters:
    value: '4'
  states: {}
- name: NLobulos
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs_user*Bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: AnchoCanales/NLobulos
  states: {}
- name: Rs_user
  id: variable
  parameters:
    value: Rs*N
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sobremuestreo
  id: variable
  parameters:
    value: '4'
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: int(samp_rate/Rs)
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0_0_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: int(samp_rate/Rs)
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0_0_0_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: int(samp_rate/Rs)
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0_0_0_1
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: int(samp_rate/Rs)
  states: {}
- name: b_signal_mult_0
  id: b_signal_mult
  parameters:
    f: 1*AnchoCanales
    samp_rate: samp_rate
  states: {}
- name: b_signal_mult_0_0
  id: b_signal_mult
  parameters:
    f: 3*AnchoCanales
    samp_rate: samp_rate
  states: {}
- name: b_signal_mult_0_0_0
  id: b_signal_mult
  parameters:
    f: 7*AnchoCanales
    samp_rate: samp_rate
  states: {}
- name: b_signal_mult_0_1
  id: b_signal_mult
  parameters:
    f: 5*AnchoCanales
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: AnchoCanales/2.
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: AnchoCanales/8.
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: AnchoCanales/2.
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: AnchoCanales/8.
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: AnchoCanales/2.
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: AnchoCanales/8.
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: AnchoCanales/2.
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: AnchoCanales/8.
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_zero_order_hold2_cc_0_0, '0', low_pass_filter_0, '0']
- [E3TRadio_zero_order_hold2_cc_0_0_0, '0', low_pass_filter_0_0, '0']
- [E3TRadio_zero_order_hold2_cc_0_0_0_0, '0', low_pass_filter_0_1, '0']
- [E3TRadio_zero_order_hold2_cc_0_0_0_1, '0', low_pass_filter_0_0_0, '0']
- [b_signal_mult_0, '0', blocks_add_xx_0, '0']
- [b_signal_mult_0_0, '0', blocks_add_xx_0, '1']
- [b_signal_mult_0_0_0, '0', blocks_add_xx_0, '3']
- [b_signal_mult_0_1, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [low_pass_filter_0, '0', b_signal_mult_0, '0']
- [low_pass_filter_0_0, '0', b_signal_mult_0_0, '0']
- [low_pass_filter_0_0_0, '0', b_signal_mult_0_0_0, '0']
- [low_pass_filter_0_1, '0', b_signal_mult_0_1, '0']
- [pad_source_0, '0', E3TRadio_zero_order_hold2_cc_0_0, '0']
- [pad_source_0_0, '0', E3TRadio_zero_order_hold2_cc_0_0_0, '0']
- [pad_source_0_0_0, '0', E3TRadio_zero_order_hold2_cc_0_0_0_1, '0']
- [pad_source_0_1, '0', E3TRadio_zero_order_hold2_cc_0_0_0_0, '0']

metadata:
  file_format: 1
