options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Hace lo mismo que el b_sampler, pero con senales complejas. Por una salida entrega la senal diezmada y por la otra muestreada. El diezmado se realiza  de la manera en que se explica el diezmado en el libro de Tratamiento de Senales y Sistemas de Oppenheim. En ese diezmado se igualan a cero periodicamente un grupo de muestras. El muestreo, que se entrega en la otra salida de este bloque es similar al diezmado, pero las muestras que se igualan a cero son anuladas, es decir, desaparecen de la senal. Por esa razon, la rata de muestreo de la senal diezmada es la misma de la que entra al bloque, pero la rata de muestreo de la senal muestreada es Sps veces menor.
    generate_options: hb
    id: b_sampler_cc
    output_language: python
    title: b_sampler_cc
  states: {}

blocks:
- name: DelayDiez
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: Sps
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: b_sampler_0_0
  id: b_sampler
  parameters:
    DelayDiez: DelayDiez
    Sps: Sps
  states: {}
- name: b_sampler_0_0_0
  id: b_sampler
  parameters:
    DelayDiez: DelayDiez
    Sps: Sps
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: diezmado
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [b_sampler_0_0, '0', blocks_float_to_complex_0, '1']
- [b_sampler_0_0, '1', blocks_float_to_complex_0_0, '1']
- [b_sampler_0_0_0, '0', blocks_float_to_complex_0, '0']
- [b_sampler_0_0_0, '1', blocks_float_to_complex_0_0, '0']
- [blocks_complex_to_float_0, '0', b_sampler_0_0_0, '0']
- [blocks_complex_to_float_0, '1', b_sampler_0_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_1, '0']
- [blocks_float_to_complex_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
