options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Se refierea al Slope Circuit que enn el libro de Haykin, capitulo 2.7 esta representado como H2(f)
    generate_options: hb
    id: b_slope_circuit_H2_cc
    output_language: python
    title: b_slope_circuit_H2_cc
  states: {}

blocks:
- name: BW
  id: parameter
  parameters:
    label: Ancho de banda
    type: eng_float
    value: '1000'
  states: {}
- name: F_muestreo
  id: parameter
  parameters:
    label: F_muestreo
    type: eng_float
    value: '1000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: BW*2*math.pi*1.j
    type: complex
  states: {}
- name: b_derivador_cc_0
  id: b_derivador_cc
  parameters:
    F_muestreo: F_muestreo
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pendiente
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pendiente
  id: parameter
  parameters:
    label: pendiente
    type: eng_float
    value: '1.'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [b_derivador_cc_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', pad_sink_1, '0']
- [blocks_multiply_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [pad_source_0, '0', b_derivador_cc_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
