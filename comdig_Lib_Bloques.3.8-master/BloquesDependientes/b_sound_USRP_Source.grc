options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Es algo parecido a un USRP Sink pero en vez de usar una antena receptora, usa el microfono del computador, en un rango de frecuencias que esta entre 0 Hz y  22500 Hz para explotar al maximo las capacidades de audio que usualmente tienen los computadores. Tiene dos salida, una es la senala bandabase, la otra es opción, para pruebaas y corresponde a la senal pasobandas. Parametros usados: samp_rate (Hz) - es la frecuencia de muestreo de la senal que entrega nuestro bloque; Fc (Hz) - es la frecuencia de la portadora; Gain Value - es la ganancia en dB del amplificador interno; B (Hz) ancho de banda del canal pasobandas.'
    generate_options: hb
    id: b_sound_USRP_Source
    output_language: python
    title: b_sound_USRP_Source
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: B/2
  states: {}
- name: Gain_volts
  id: variable
  parameters:
    value: math.pow(10,Gain_dB/20.)
  states: {}
- name: samp_rate_passband
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: B
  id: parameter
  parameters:
    label: Bandwidth (Hz)
    value: '2000'
  states: {}
- name: Fc
  id: parameter
  parameters:
    label: Center Freq (Hz)
    value: '4000'
  states: {}
- name: Gain_dB
  id: parameter
  parameters:
    label: Gain Value (dB)
    value: '0.'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate_passband
  states: {}
- name: b_downconverter_fc_0
  id: b_downconverter_fc
  parameters:
    BW: BW
    Fc: Fc
    samp_rate: samp_rate_passband
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Gain_volts
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: passband
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate_passband
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate (Hz)
    value: '2000'
  states: {}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [b_downconverter_fc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', b_downconverter_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_1_0, '0']
- [rational_resampler_xxx_0, '0', pad_sink_1, '0']

metadata:
  file_format: 1
