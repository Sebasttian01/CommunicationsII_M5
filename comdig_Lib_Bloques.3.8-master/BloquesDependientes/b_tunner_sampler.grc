options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Permite sintonizar manualmente el canal, usando visores y reguladores, al punto de entregar la senal correctamente muestreada. Parametros usados: samp_rate (Hz) la frecuencia de muestreo de la senal entrante; sps (muestras) numero de muestras por simbolo en la senal entrante; Delay Tuning (muestras) el retrazo que se introduce a la senal antes de aplicarle el muestreo; PhiTuning (Rad) angulo usado para corregir la desviacion de angulo producida por el canal; F_Tuning (Hz) correccion de la desviacion de frecuencias; Nscope (muestras) numero de bits a mostrar en el scope; Nscope_spanNscope_span numero de bits a mostrar en el osciloscopio donde se selecciona el muestreo; DelayTuningInicial (muestras) es un valor sugerido de arranque para la sintonizacion del retardo para el muestreo'
    generate_options: hb_qt_gui
    id: b_tunner_sampler
    output_language: python
    title: b_tunner_sampler
  states: {}

blocks:
- name: DelayTuning
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: 'Retardo antes de muestreo '
    rangeType: int
    start: '0'
    step: '1'
    stop: sps-1
    value: DelayTuningInicial
  states: {}
- name: EyeDelay
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Retardo para Centrado del Ojo
    rangeType: int
    start: '0'
    step: '1'
    stop: sps*4
    value: '0'
  states: {}
- name: F_Tuning
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Rx Frequency tunining
    start: '0'
    step: 10./1000.
    stop: '10.'
    value: '0'
  states: {}
- name: PhiTuning
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Rx angle tunining
    start: '0'
    step: (numpy.pi)*2/200
    stop: (numpy.pi)*2
    value: '0'
  states: {}
- name: AlphaLineasOjo
  id: parameter
  parameters:
    label: AlphaLineasOjo
    value: '1.0'
  states: {}
- name: DelayTuningInicial
  id: parameter
  parameters:
    label: DelayTuning inicial
    type: intx
    value: '0'
  states: {}
- name: GrosorLineasOjo
  id: parameter
  parameters:
    label: GrosorLineasOjo
    value: '1'
  states: {}
- name: b_Eye_Diagram_0
  id: b_Eye_Diagram
  parameters:
    AlphaLineas: AlphaLineasOjo
    Delay_i: '0'
    GrosorLineas: GrosorLineasOjo
    N_eyes: '2'
    Samprate: samp_rate
    Sps: sps
    Title: '"Eye Diagramm. Parte Real"'
    Ymax: '0.2'
    Ymin: '-0.2'
    gui_hint: 4,0,1,2
  states: {}
- name: b_Eye_Diagram_0_0
  id: b_Eye_Diagram
  parameters:
    AlphaLineas: AlphaLineasOjo
    Delay_i: '0'
    GrosorLineas: GrosorLineasOjo
    N_eyes: '2'
    Samprate: samp_rate
    Sps: sps
    Title: '"Eye Diagramm. Parte Imaginaria"'
    Ymax: '0.2'
    Ymin: '-0.2'
    gui_hint: 5,0,1,2
  states: {}
- name: b_sampler_cc_0
  id: b_sampler_cc
  parameters:
    DelayDiez: '0'
    Sps: sps
  states: {}
- name: b_tunner_0
  id: b_tunner
  parameters:
    Ganancia_ajuste_dB: '0'
    NDelay: DelayTuning
    fdesv: '-F_Tuning'
    phi: PhiTuning
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: Entrante
    label2: Saliente
    name: '"Rx tunner"'
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '0.2'
    xmin: '-0.2'
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: Rx
    name: '"Rx sampled"'
    size: '1024'
    type: complex
    xmax: '0.2'
    xmin: '-0.2'
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: '1000'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: sps
    type: intx
    value: '8'
  states: {}

connections:
- [b_sampler_cc_0, '0', blocks_complex_to_float_0, '0']
- [b_sampler_cc_0, '0', qtgui_const_sink_x_0_0_0, '1']
- [b_sampler_cc_0, '1', pad_sink_0, '0']
- [b_sampler_cc_0, '1', qtgui_const_sink_x_0_0_0_0, '0']
- [b_tunner_0, '0', b_sampler_cc_0, '0']
- [b_tunner_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_complex_to_float_0, '0', b_Eye_Diagram_0, '0']
- [blocks_complex_to_float_0, '1', b_Eye_Diagram_0_0, '0']
- [blocks_complex_to_float_0_0, '0', b_Eye_Diagram_0, '1']
- [blocks_complex_to_float_0_0, '1', b_Eye_Diagram_0_0, '1']
- [pad_source_0, '0', b_tunner_0, '0']
- [pad_source_0, '0', qtgui_const_sink_x_0_0_0, '0']

metadata:
  file_format: 1
