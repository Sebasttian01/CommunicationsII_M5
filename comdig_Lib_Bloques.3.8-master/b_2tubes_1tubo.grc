options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    description: Usado para acomodar dos chorros de datos de diferentes velocidades (dos tubos) en un solo gran tubo. N1 es el numero de espacios que ocupa en el gran tubo, el primer tubo. N2 es para el segunto tubo
    generate_options: hb
    id: b_2tubes_1tube
    output_language: python
    title: b_2tubes_1tube
  states: {}

blocks:
- name: N1
  id: parameter
  parameters:
    value: '5'
  states: {}
- name: N2
  id: parameter
  parameters:
    value: '3'
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: N1
    type: complex
  states: {}
- name: blocks_stream_to_streams_1
  id: blocks_stream_to_streams
  parameters:
    num_streams: N2
    type: complex
  states: {}
- name: blocks_streams_to_stream_0
  id: blocks_streams_to_stream
  parameters:
    num_streams: N1+N2
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}

connections:
- [blocks_stream_to_streams_0, '0', blocks_streams_to_stream_0, '0']
- [blocks_stream_to_streams_0, '1', blocks_streams_to_stream_0, '1']
- [blocks_stream_to_streams_0, '2', blocks_streams_to_stream_0, '2']
- [blocks_stream_to_streams_0, '3', blocks_streams_to_stream_0, '3']
- [blocks_stream_to_streams_0, '4', blocks_streams_to_stream_0, '4']
- [blocks_stream_to_streams_1, '0', blocks_streams_to_stream_0, '5']
- [blocks_stream_to_streams_1, '1', blocks_streams_to_stream_0, '6']
- [blocks_stream_to_streams_1, '2', blocks_streams_to_stream_0, '7']
- [blocks_streams_to_stream_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_stream_to_streams_0, '0']
- [pad_source_0_0, '0', blocks_stream_to_streams_1, '0']

metadata:
  file_format: 1
