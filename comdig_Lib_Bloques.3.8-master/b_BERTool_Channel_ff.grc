options:
  parameters:
    author: 'Mancipe Andres, Padilla Astrid, Castillo Jeyson '
    category: '''[comdiguis]'''
    description: 'Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular y grafica la curva de BER (Bit error Rate) o SER (simbol error ratio) para una senal con modulacion digital. Parametros usados: N_snr - numero de puntos que tendra la curva de BER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la entrante envolvente compleja de la señal modulada. Las salidas del bloque son: out env que es la saliente envolvente compleja con la adicion de ruido AWGN; out ser que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo bits, luego obtenemos curva de BER, pero si M>2 estamos hablando de curva de SER. '
    generate_options: hb_qt_gui
    id: b_BERTool_Channel_ff
    output_language: python
    title: b_BERTool_Channel_ff
  states: {}

blocks:
- name: B
  id: parameter
  parameters:
    label: B
    value: '128'
  states: {state: disabled}
- name: E3TRadio_e_BERtool_0_0
  id: E3TRadio_e_BERtool
  parameters:
    N: N_snr
  states: {}
- name: E3TRadio_e_canal_BER_0_0
  id: E3TRadio_e_canal_BER
  parameters:
    B: Rs
    EsN0max: EsN0max
    EsN0min: EsN0min
    N: N_snr
    Rs: Rs
  states: {}
- name: EsN0max
  id: parameter
  parameters:
    label: EsN0max
    value: '20'
  states: {}
- name: EsN0min
  id: parameter
  parameters:
    label: EsN0min
    value: '0'
  states: {}
- name: N_snr
  id: parameter
  parameters:
    label: N_snr
    value: '128'
  states: {}
- name: Rs
  id: parameter
  parameters:
    label: Rs
    value: '125'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_snr
    type: float
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out_env
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in_Tx
    type: byte
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: in_Rx
    type: byte
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    alpha1: '1'
    label1: tipo_mod
    name: '"Curva de BER"'
    showports: 'True'
    vlen: N_snr
    width1: '6'
    x_axis_label: '"Es/N0 [dB]"'
    x_start: EsN0min
    x_step: (EsN0max-EsN0min)/float(N_snr)
    x_units: '"dB"'
    y_axis_label: '"10logPe"'
    ymax: '0'
    ymin: '-4'
  states: {}
- name: tipo_mod
  id: parameter
  parameters:
    label: tipo_mod
    value: '"QPSK"'
  states: {}

connections:
- [E3TRadio_e_BERtool_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [E3TRadio_e_canal_BER_0_0, '0', blocks_complex_to_float_0, '0']
- [E3TRadio_e_canal_BER_0_0, '1', E3TRadio_e_BERtool_0_0, '0']
- [blocks_complex_to_float_0, '0', pad_sink_0_0_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_float_to_complex_0, '0', E3TRadio_e_canal_BER_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_stream_to_vector_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [pad_source_0_0, '0', blocks_float_to_complex_0, '0']
- [pad_source_0_0_0, '0', E3TRadio_e_BERtool_0_0, '1']
- [pad_source_0_0_0_0, '0', E3TRadio_e_BERtool_0_0, '2']

metadata:
  file_format: 1
