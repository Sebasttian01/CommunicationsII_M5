options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    description: 'Este Bloque sirve a la vez como canal de Ruido Blanco Gausiano y como herramienta para calcular la curva de BER (Bit error Rate) para una senal binaria real. Pero tambien se puede usar para señales M-arias reales como M-PAM. Se pueden usar señales que han pasado por un filtroformador de pulsos. En caso de que la entrada sea una señal binara, siempre que se hable de simbolos es lo mismo que hablar de bits, es decir, los simbolos son bits puros. Parametros usados: Sps - es el número muestras por simbolo, en caso de no usar un filtro formador de pulsos Sps=1, recuerde que Sps=samp_reate/Sps; Rs - es la rata de simbolos; N_snr - numero de puntos que tendra la curva de BER; EsNomin: valor minimo de la relación Es/No; EsNomax: valor máximo de la relacion Es/No. Las señales de entrada son: in Tx  para los  simbolos transmitidos; in Rx  para los simbolos recibidos; in es la señal enviada. La salida son dos senales: out - es la Curva de BER o SER a graficar;  out_env - es la señal que sale del canal AWGN, que es la misma entrante pero con ruido ; out que son los valores de BER o SER disponibles. IMPORTANTE: que la curva sea BER o sea SER lo define el tipo de senal que se tiene en in Tx y en in Rx, donde se tiene en cada caso una senal M-aria. Asi que si M=2, estamos enviando y recibiendo simbolos, luego obtenemos curva de BER, pero si M>2 estamos hablando de curva de SER.'
    generate_options: hb
    id: b_BERTool_ff
    output_language: python
    title: b_BERTool_ff
  states: {}

blocks:
- name: B
  id: parameter
  parameters:
    label: B
    value: '128'
  states: {state: disabled}
- name: E3TRadio_e_BERtool_0
  id: E3TRadio_e_BERtool
  parameters:
    N: N_snr
  states: {}
- name: E3TRadio_e_canal_BER_0
  id: E3TRadio_e_canal_BER
  parameters:
    B: Rs*Sps
    EsN0max: EsN0max/2.
    EsN0min: EsN0min/2.
    N: N_snr
    Rs: Rs
  states: {}
- name: E3TRadio_zero_order_hold_bb_0
  id: E3TRadio_zero_order_hold_bb
  parameters:
    k: Sps
  states: {}
- name: E3TRadio_zero_order_hold_bb_0_0
  id: E3TRadio_zero_order_hold_bb
  parameters:
    k: Sps
  states: {}
- name: EsN0max
  id: parameter
  parameters:
    label: EsN0max
    value: '20'
  states: {}
- name: EsN0min
  id: parameter
  parameters:
    label: EsN0min
    value: '0'
  states: {}
- name: N_snr
  id: parameter
  parameters:
    label: N_snr
    value: '128'
  states: {}
- name: Rs
  id: parameter
  parameters:
    label: Rs
    value: '125'
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    type: eng_float
    value: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N_snr
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: NOTA PARA MEJORAR ESTE BLOQUE. Se proponen las siguientes modificaciones; 1) mejorar el canal para que tenga dos entradas, una para la señal modulada, otra para recibir el monto de ruido requerido (No o Pn o Es/No o SNR) 2) complementar  el e_BERToll  para que asuma el roll de ordenar la SNR requerida. 3) optimizar e_BERToll para que haga promediados más largos y enfatice en los valors SNR que sean más relevantes, evitando con ello recalcular parte de las curvas que van quedando bien definidas y concentrandose donde no están tan definidas.
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: out_env
    type: float
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: N_snr
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in_Tx
    type: byte
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: in_Rx
    type: byte
  states: {}
- name: tipo_mod
  id: parameter
  parameters:
    label: tipo_mod
    value: '"QPSK"'
  states: {state: disabled}

connections:
- [E3TRadio_e_BERtool_0, '0', blocks_nlog10_ff_0, '0']
- [E3TRadio_e_canal_BER_0, '0', blocks_complex_to_float_0, '0']
- [E3TRadio_e_canal_BER_0, '1', E3TRadio_e_BERtool_0, '0']
- [E3TRadio_zero_order_hold_bb_0, '0', E3TRadio_e_BERtool_0, '1']
- [E3TRadio_zero_order_hold_bb_0_0, '0', E3TRadio_e_BERtool_0, '2']
- [blocks_complex_to_float_0, '0', pad_sink_0_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_float_to_complex_0, '0', E3TRadio_e_canal_BER_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_stream_to_vector_0, '0', pad_sink_0_0_0_0, '0']
- [pad_source_0_0, '0', blocks_float_to_complex_0, '0']
- [pad_source_0_0_0, '0', E3TRadio_zero_order_hold_bb_0, '0']
- [pad_source_0_0_0_0, '0', E3TRadio_zero_order_hold_bb_0_0, '0']

metadata:
  file_format: 1
