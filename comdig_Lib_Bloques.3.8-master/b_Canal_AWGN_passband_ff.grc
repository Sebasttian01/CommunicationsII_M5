options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Este bloque es un simulador de un canal AWGN en version pasobandas con ruido aditivo de banda angosta pasobandas. De modo que tiene las siguientes características: suma ruido blanco a la señal,  restringe el ancho de banda e Introduce un retardo a la señal. Parametros: Ch_NodB - altura de la PSD del ruido blanco bandabase; samp_rate - frecuencia de muestreo de la señal; B - ancho de banda bandabase, Fc frecuencia central, Ch_Toffset - retardo dado en muestraas que el canal introduce'
    generate_options: hb
    id: b_Canal_AWGN_passband_ff
    output_language: python
    title: b_Canal_AWGN_passband_ff
  states: {}

blocks:
- name: 'No'
  id: variable
  parameters:
    value: math.pow(10.,(Ch_NodB)/10.)
  states: {}
- name: P
  id: variable
  parameters:
    value: No*10000
  states: {}
- name: Vrms
  id: variable
  parameters:
    value: math.sqrt(P)
  states: {}
- name: B
  id: parameter
  parameters:
    label: B (Hz)
    type: eng_float
    value: '1000'
  states: {}
- name: Ch_NodB
  id: parameter
  parameters:
    label: Ch. W.Noise (No in dB)
    type: intx
    value: '1000'
  states: {}
- name: Ch_Toffset
  id: parameter
  parameters:
    label: Channel Toffset
    type: intx
    value: '0'
  states: {}
- name: Fc
  id: parameter
  parameters:
    label: Fc
    type: intx
    value: '1000'
  states: {}
- name: Note
  id: note
  parameters:
    note: Esta ramificacion de abajo es la que introduce las fluctuaciones en magnitud
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Vrms
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: Fc+B/2
    low_cutoff_freq: Fc-B/2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: (B/2)/16
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Ch_Toffset
    type: float
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: intx
    value: '1000'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0, '0', pad_sink_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
