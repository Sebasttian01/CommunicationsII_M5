options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    description: Realiza el scrambling
    generate_options: hb
    id: b_De_scrambling_bb
    output_language: python
    title: b_De_scrambling_bb
  states: {}

blocks:
- name: analog_random_uniform_source_x_0_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: semilla
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: retardo
    type: byte
  states: {}
- name: e_Multiply
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """Multiplica dos senales tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_Multiply_bb',   # will show up in GRC
                  in_sig=[np.int8, np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]*input_items[1]
              return len(output_items[0])
  states: {}
- name: e_bipol_to_unip
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de bipolar a unipolar una senal tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_bipolar_to_unipolar_bb',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):

              output_items[0][:] = (input_items[0]+1)/2
              return len(output_items[0])
  states: {}
- name: e_unip_to_bipol
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):  
      #    """convierte de unipolar a bipolar una senal tipo char"""
          def __init__(self,):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='e_unipolar to bipolar_bb',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )

          def work(self, input_items, output_items):

              output_items[0][:] = input_items[0]*2-1
              return len(output_items[0])
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: retardo
  id: parameter
  parameters:
    label: retardo
    type: intx
    value: '0'
  states: {}
- name: semilla
  id: parameter
  parameters:
    label: semilla
    type: intx
    value: '42'
  states: {}

connections:
- [analog_random_uniform_source_x_0_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', e_unip_to_bipol, '0']
- [e_Multiply, '0', e_bipol_to_unip, '0']
- [e_bipol_to_unip, '0', pad_sink_0_0, '0']
- [e_unip_to_bipol, '0', e_Multiply, '1']
- [pad_source_0_0, '0', e_Multiply, '0']

metadata:
  file_format: 1
