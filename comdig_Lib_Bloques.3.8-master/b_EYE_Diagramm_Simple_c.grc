options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander'
    category: '''[comdiguis]'''
    description: 'Let you to see the eye diagram of complex signals. Parametros usados: Delay_i - es un retardo para que el ojo se centre al gusto del usuario'
    generate_options: hb_qt_gui
    id: b_Eye_Diagram_simple_c
    output_language: python
    title: b_Eye_Diagram_simple_c
  states: {}

blocks:
- name: Delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    label: Mueva aqui para Centrar el Ojo
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps
    value: Delay_i
  states: {}
- name: Samprate
  id: variable
  parameters:
    value: Samprate1*Kint
  states: {}
- name: Sps
  id: variable
  parameters:
    value: Sps1*Kint
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0
    label: 'Diagrama de Ojo '
    type: string
    value: Title
  states: {}
- name: AlphaLineas
  id: parameter
  parameters:
    label: AlphaLineas
    value: '0.5'
  states: {}
- name: Delay
  id: parameter
  parameters:
    label: Delay in samples
    type: intx
    value: '0'
  states: {state: disabled}
- name: Delay_i
  id: parameter
  parameters:
    label: Delay_i
    type: intx
    value: '0'
  states: {}
- name: GrosorLineas
  id: parameter
  parameters:
    label: GrosorLineas
    value: '20'
  states: {}
- name: Kint
  id: parameter
  parameters:
    label: Inteporlacion
    type: intx
    value: '1'
  states: {}
- name: N_eyes
  id: parameter
  parameters:
    label: Number of eyes
    type: intx
    value: '2'
  states: {}
- name: Samprate1
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '1000'
  states: {}
- name: Sps1
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '64'
  states: {}
- name: Title
  id: parameter
  parameters:
    label: Titulo de la grafica
    value: '"Eye Diagramm"'
  states: {}
- name: Ymax
  id: parameter
  parameters:
    label: Ymax
    type: eng_float
    value: '2'
  states: {}
- name: Ymin
  id: parameter
  parameters:
    label: Ymin
    type: eng_float
    value: '-2'
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Sps*2+Delay
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: Sps*3+Delay
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: Sps*3+Delay
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: Sps*4+Delay
    type: float
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: Sps*4+Delay
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: Sps*5+Delay
    type: float
  states: {}
- name: blocks_delay_0_2_0
  id: blocks_delay
  parameters:
    delay: Sps*5+Delay
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: Sps*6+Delay
    type: float
  states: {}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: Sps*9+Delay
    type: float
  states: {}
- name: blocks_delay_0_3_0_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: float
  states: {}
- name: blocks_delay_0_3_0_0_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: float
  states: {}
- name: blocks_delay_0_3_0_1
  id: blocks_delay
  parameters:
    delay: Sps*9+Delay
    type: float
  states: {}
- name: blocks_delay_0_3_1
  id: blocks_delay
  parameters:
    delay: Sps*6+Delay
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: Sps*7+Delay
    type: float
  states: {}
- name: blocks_delay_0_4_0
  id: blocks_delay
  parameters:
    delay: Sps*7+Delay
    type: float
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: Sps*8+Delay
    type: float
  states: {}
- name: blocks_delay_0_5_0
  id: blocks_delay
  parameters:
    delay: Sps*8+Delay
    type: float
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: Sps*1+Delay
    type: float
  states: {}
- name: blocks_delay_0_6_0
  id: blocks_delay
  parameters:
    delay: Sps*1+Delay
    type: float
  states: {}
- name: blocks_delay_0_7
  id: blocks_delay
  parameters:
    delay: Sps*2+Delay
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: AlphaLineas
    alpha10: AlphaLineas
    alpha2: AlphaLineas
    alpha3: AlphaLineas
    alpha4: AlphaLineas
    alpha5: AlphaLineas
    alpha6: AlphaLineas
    alpha7: AlphaLineas
    alpha8: AlphaLineas
    alpha9: AlphaLineas
    gui_hint: 1,0
    label1: D
    label10: D
    label2: D
    label3: D
    label4: D
    label5: D
    label6: D
    label7: D
    label8: D
    label9: D
    name: '''Re.''+Title'
    nconnections: '10'
    size: int(Sps*N_eyes)
    srate: Samprate
    type: float
    update_time: '1'
    width1: GrosorLineas
    width10: GrosorLineas
    width2: GrosorLineas
    width3: GrosorLineas
    width4: GrosorLineas
    width5: GrosorLineas
    width6: GrosorLineas
    width7: GrosorLineas
    width8: GrosorLineas
    width9: GrosorLineas
    ymax: Ymax
    ymin: Ymin
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: AlphaLineas
    alpha10: AlphaLineas
    alpha2: AlphaLineas
    alpha3: AlphaLineas
    alpha4: AlphaLineas
    alpha5: AlphaLineas
    alpha6: AlphaLineas
    alpha7: AlphaLineas
    alpha8: AlphaLineas
    alpha9: AlphaLineas
    gui_hint: 1,1
    label1: D
    label10: D
    label2: D
    label3: D
    label4: D
    label5: D
    label6: D
    label7: D
    label8: D
    label9: D
    name: '''Im.''+Title'
    nconnections: '10'
    size: int(Sps*N_eyes)
    srate: Samprate
    type: float
    update_time: '1'
    width1: GrosorLineas
    width10: GrosorLineas
    width2: GrosorLineas
    width3: GrosorLineas
    width4: GrosorLineas
    width5: GrosorLineas
    width6: GrosorLineas
    width7: GrosorLineas
    width8: GrosorLineas
    width9: GrosorLineas
    ymax: Ymax
    ymin: Ymin
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: Kint
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0_0, '0', blocks_delay_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_1, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_2, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_3, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_3_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_3_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_4, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_5, '0']
- [blocks_complex_to_float_0_0, '0', blocks_delay_0_6, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_1_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_2_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_3_0_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_3_0_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_3_1, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_4_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_5_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_6_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_7, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_delay_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '2']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_0_0, '3']
- [blocks_delay_0_1_0, '0', qtgui_time_sink_x_0_0_0_0, '3']
- [blocks_delay_0_2, '0', qtgui_time_sink_x_0_0_0, '4']
- [blocks_delay_0_2_0, '0', qtgui_time_sink_x_0_0_0_0, '4']
- [blocks_delay_0_3, '0', qtgui_time_sink_x_0_0_0, '5']
- [blocks_delay_0_3_0, '0', qtgui_time_sink_x_0_0_0, '8']
- [blocks_delay_0_3_0_0, '0', qtgui_time_sink_x_0_0_0, '9']
- [blocks_delay_0_3_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '9']
- [blocks_delay_0_3_0_1, '0', qtgui_time_sink_x_0_0_0_0, '8']
- [blocks_delay_0_3_1, '0', qtgui_time_sink_x_0_0_0_0, '5']
- [blocks_delay_0_4, '0', qtgui_time_sink_x_0_0_0, '6']
- [blocks_delay_0_4_0, '0', qtgui_time_sink_x_0_0_0_0, '6']
- [blocks_delay_0_5, '0', qtgui_time_sink_x_0_0_0, '7']
- [blocks_delay_0_5_0, '0', qtgui_time_sink_x_0_0_0_0, '7']
- [blocks_delay_0_6, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_delay_0_6_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_delay_0_7, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [pad_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0_0, '0']

metadata:
  file_format: 1
