options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander'
    category: '''[comdiguis]'''
    description: Let you to see not only the eye diagram but also let to make the timing visually and manually. But not only, it also makes the sampling. The key parameter is Retardo_Timing
    generate_options: hb_qt_gui
    id: b_EYE_Timing_sampler_f
    output_language: python
    title: b_EYE_Timing_sampler_f
  states: {}

blocks:
- name: Delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    label: Centrar el Ojo
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps
    value: Delay_i
    widget: counter
  states: {state: disabled}
- name: Retardo_Timing
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Retardo_Timing
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '7'
  states: {}
- name: AlphaLineas
  id: parameter
  parameters:
    label: AlphaLineas
    value: '0.5'
  states: {}
- name: Delay
  id: parameter
  parameters:
    label: Delay
    type: intx
    value: '0'
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: Retardo_Timing
    N: Sps
  states: {}
- name: E3TRadio_diezmoppenh3_ff_0
  id: E3TRadio_diezmoppenh3_ff
  parameters:
    M: Retardo_Timing
    N: Sps
  states: {}
- name: GrosorLineas
  id: parameter
  parameters:
    label: GrosorLineas
    value: '20'
  states: {}
- name: N_eyes
  id: parameter
  parameters:
    label: Number of eyes
    type: intx
    value: '2'
  states: {}
- name: Retardo_Timing
  id: parameter
  parameters:
    label: Retardo_Timing
    type: intx
    value: '0'
  states: {state: disabled}
- name: Samprate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: '1000'
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Samples per symbol
    type: intx
    value: '64'
  states: {}
- name: Title
  id: parameter
  parameters:
    label: Titulo de la grafica
    value: '"Eye Diagram and Timing"'
  states: {}
- name: Ymax
  id: parameter
  parameters:
    label: Ymax
    type: eng_float
    value: '2'
  states: {}
- name: Ymin
  id: parameter
  parameters:
    label: Ymin
    type: eng_float
    value: '-2'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Sps*2+Delay
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: Sps*3+Delay
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: Sps*4+Delay
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: Sps*5+Delay
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: Sps*6+Delay
    type: float
  states: {}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: Sps*9+Delay
    type: float
  states: {}
- name: blocks_delay_0_3_0_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: float
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: Sps*7+Delay
    type: float
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: Sps*8+Delay
    type: float
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: Sps*1+Delay
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: AlphaLineas
    alpha10: '1.'
    alpha2: AlphaLineas
    alpha3: AlphaLineas
    alpha4: AlphaLineas
    alpha5: AlphaLineas
    alpha6: AlphaLineas
    alpha7: AlphaLineas
    alpha8: AlphaLineas
    alpha9: AlphaLineas
    gui_hint: 1,0,1,1
    label1: '.'
    label10: sampled signal
    label2: '.'
    label3: '.'
    label4: '.'
    label5: '.'
    label6: '.'
    label7: '.'
    label8: '.'
    label9: '.'
    marker10: '0'
    name: Title
    nconnections: '10'
    size: int(Sps*N_eyes)
    srate: Samprate
    type: float
    width1: GrosorLineas
    width2: GrosorLineas
    width3: GrosorLineas
    width4: GrosorLineas
    width5: GrosorLineas
    width6: GrosorLineas
    width7: GrosorLineas
    width8: GrosorLineas
    width9: GrosorLineas
    ymax: Ymax
    ymin: Ymin
  states: {}

connections:
- [E3TRadio_diezma_ff_0, '0', pad_sink_0, '0']
- [E3TRadio_diezmoppenh3_ff_0, '0', E3TRadio_diezma_ff_0, '0']
- [E3TRadio_diezmoppenh3_ff_0, '0', blocks_delay_0_3_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_0_0, '3']
- [blocks_delay_0_2, '0', qtgui_time_sink_x_0_0_0, '4']
- [blocks_delay_0_3, '0', qtgui_time_sink_x_0_0_0, '5']
- [blocks_delay_0_3_0, '0', qtgui_time_sink_x_0_0_0, '8']
- [blocks_delay_0_3_0_0, '0', qtgui_time_sink_x_0_0_0, '9']
- [blocks_delay_0_4, '0', qtgui_time_sink_x_0_0_0, '6']
- [blocks_delay_0_5, '0', qtgui_time_sink_x_0_0_0, '7']
- [blocks_delay_0_6, '0', qtgui_time_sink_x_0_0_0, '0']
- [pad_source_0, '0', E3TRadio_diezmoppenh3_ff_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_1, '0']
- [pad_source_0, '0', blocks_delay_0_2, '0']
- [pad_source_0, '0', blocks_delay_0_3, '0']
- [pad_source_0, '0', blocks_delay_0_3_0, '0']
- [pad_source_0, '0', blocks_delay_0_4, '0']
- [pad_source_0, '0', blocks_delay_0_5, '0']
- [pad_source_0, '0', blocks_delay_0_6, '0']

metadata:
  file_format: 1
