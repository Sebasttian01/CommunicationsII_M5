options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    description: 'Recibe una senal digital con modulacion basada en constelaciones, luego de pasar por un canal que introduce desviaciones en fase y frecuencia, para entregar una constelacion estable, pues corrige esas desviaciones. Parametros usados: Constellation - es el mvector que contiene los puntos de la constelacion usada, lo cual sirve de base para poder realizar las correcciones. '
    generate_options: hb
    id: b_FLL_tunner2
    output_language: python
    title: b_FLL_tunner2
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(Constellation)
  states: {}
- name: my_constell_obj
  id: variable_constellation
  parameters:
    const_points: Constellation
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: np.arange(0,M)
    type: calcdist
  states: {}
- name: Constellation
  id: parameter
  parameters:
    label: Constellation
    value: (1,0)
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: my_constell_obj
    fmax: '0.25'
    fmin: '-0.25'
    loop_bw: 2*math.pi/100.0
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_1_1_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_1, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', pad_sink_1, '0']
- [pad_source_0, '0', digital_constellation_receiver_cb_0, '0']

metadata:
  file_format: 1
