options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    description: 'Recibe una senal digital con modulacion basada en constelaciones, luego de pasar por un canal que introduce desviaciones en fase y frecuencia, para entregar una constelacion estable, pues corrige esas desviaciones. Parametros usados: Constellation Object - es el modelo que contiene toda la informacion de la constelacion usada, lo cual sirve de base para poder realizar las correcciones. El constellation Object se puede crear mediante el bloque "Constellation Object"'
    generate_options: hb
    id: b_FLL_tunner
    output_language: python
    title: b_FLL_tunner
  states: {}

blocks:
- name: ConstellationObject
  id: parameter
  parameters:
    label: Constellation Object
    value: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: ConstellationObject
    fmax: '0.25'
    fmin: '-0.25'
    loop_bw: 2*math.pi/100.0
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_1, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', pad_sink_1, '0']
- [pad_source_0, '0', digital_constellation_receiver_cb_0, '0']

metadata:
  file_format: 1
