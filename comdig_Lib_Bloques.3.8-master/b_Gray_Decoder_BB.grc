options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    description: apply Gray Decoding to input byte signal. This block may be paired with b_Gray_Encoder_BB
    generate_options: hb
    id: b_Gray_Decoder_BB
    output_language: python
    title: b_Gray_Decoder_BB
  states: {}

blocks:
- name: cod_gray
  id: variable
  parameters:
    value: digital.utils.gray_code.gray_code(M)
  states: {}
- name: cod_gray_inv
  id: variable
  parameters:
    value: digital.mod_codes.invert_code(cod_gray)
  states: {}
- name: M
  id: parameter
  parameters:
    label: Modulus
    type: intx
    value: '8'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: cod_gray_inv
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [digital_map_bb_0, '0', pad_sink_1, '0']
- [pad_source_0_0, '0', digital_map_bb_0, '0']

metadata:
  file_format: 1
