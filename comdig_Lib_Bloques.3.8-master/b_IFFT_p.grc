options:
  parameters:
    category: '''[comdiguis]'''
    generate_options: hb
    id: b_IFFT_p
    output_language: python
    title: b_IFFT_p
  states: {}

blocks:
- name: Nu
  id: parameter
  parameters:
    value: '8'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: Nu
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: Nu
    type: complex
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: Nu
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(Nu)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out0
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out1
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out2
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: out3
    type: complex
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: out4
    type: complex
  states: {}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: out5
    type: complex
  states: {}
- name: pad_sink_6
  id: pad_sink
  parameters:
    label: out6
    type: complex
  states: {}
- name: pad_sink_7
  id: pad_sink
  parameters:
    label: out7
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: in2
    type: complex
  states: {}
- name: pad_source_3
  id: pad_source
  parameters:
    label: in3
    type: complex
  states: {}
- name: pad_source_4
  id: pad_source
  parameters:
    label: in4
    type: complex
  states: {}
- name: pad_source_5
  id: pad_source
  parameters:
    label: in5
    type: complex
  states: {}
- name: pad_source_6
  id: pad_source
  parameters:
    label: in6
    type: complex
  states: {}
- name: pad_source_7
  id: pad_source
  parameters:
    label: in7
    type: complex
  states: {}

connections:
- [blocks_streams_to_vector_0, '0', fft_vxx_1_0, '0']
- [blocks_vector_to_streams_0, '0', pad_sink_0, '0']
- [blocks_vector_to_streams_0, '1', pad_sink_1, '0']
- [blocks_vector_to_streams_0, '2', pad_sink_2, '0']
- [blocks_vector_to_streams_0, '3', pad_sink_3, '0']
- [blocks_vector_to_streams_0, '4', pad_sink_4, '0']
- [blocks_vector_to_streams_0, '5', pad_sink_5, '0']
- [blocks_vector_to_streams_0, '6', pad_sink_6, '0']
- [blocks_vector_to_streams_0, '7', pad_sink_7, '0']
- [fft_vxx_1_0, '0', blocks_vector_to_streams_0, '0']
- [pad_source_0, '0', blocks_streams_to_vector_0, '0']
- [pad_source_1, '0', blocks_streams_to_vector_0, '1']
- [pad_source_2, '0', blocks_streams_to_vector_0, '2']
- [pad_source_3, '0', blocks_streams_to_vector_0, '3']
- [pad_source_4, '0', blocks_streams_to_vector_0, '4']
- [pad_source_5, '0', blocks_streams_to_vector_0, '5']
- [pad_source_6, '0', blocks_streams_to_vector_0, '6']
- [pad_source_7, '0', blocks_streams_to_vector_0, '7']

metadata:
  file_format: 1
