options:
  parameters:
    category: '''[comdiguis]'''
    generate_options: hb
    id: b_LMS_Equalizer2_cc
    output_language: python
    title: b_LMS_Equalizer2_cc
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: Constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: numpy.arange(M)
    type: calcdist
  states: {}
- name: eq_gain
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Constelacion
  id: parameter
  parameters:
    label: Constelacion
    value: '[(1.41 + 1.41*1j),  (-1.41 + 1.41*1j), (-1.41 - 1.41*1j), (1.41 - 1.41*1j)]'
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    value: '1'
  states: {}
- name: digital_lms_dd_equalizer_cc_0
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: MiconstellationObject
    mu: eq_gain
    num_taps: ntaps
    sps: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: ntaps
  id: parameter
  parameters:
    label: ntaps
    value: '11'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [digital_lms_dd_equalizer_cc_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', digital_lms_dd_equalizer_cc_0, '0']

metadata:
  file_format: 1
