options:
  parameters:
    category: '''[comdiguis]'''
    generate_options: hb
    id: b_MS
    output_language: python
    title: b_MS
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(len(Constelacion),2))
  states: {}
- name: Constelacion
  id: parameter
  parameters:
    label: Tabla de Verdad
    value: '[1+.0j,-1+.0j, .0+1j,0 -1j ]'
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: N
  states: {}
- name: N
  id: parameter
  parameters:
    label: Sobremuestreo
    type: intx
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Constelacion
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}

connections:
- [E3TRadio_zero_order_hold2_cc_0, '0', pad_sink_1, '0']
- [analog_random_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', E3TRadio_zero_order_hold2_cc_0, '0']

metadata:
  file_format: 1
