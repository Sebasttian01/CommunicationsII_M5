options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    description: genera la senal modulada en bandabase de una estacion movil. A diferencia del b_MS, la senal que se genera no es aleatoria, sino que esta dada por un vector que representa la senal binaria del usuario. Es util cuando se realizan pruebas para conocer si lo que se recibe es lo mismo que se envia, gracias a que los datos se repiten periodicamente
    generate_options: hb
    id: b_MS_vector
    output_language: python
    title: b_MS_vector
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(len(Constelacion),2))
  states: {}
- name: Constelacion
  id: parameter
  parameters:
    label: Tabla Verdad
    value: '[1+.0j,-1+.0j, .0+1j,0 -1j ]'
  states: {}
- name: E3TRadio_zero_order_hold2_cc_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: N
  states: {}
- name: N
  id: parameter
  parameters:
    label: sps
    type: intx
    value: '1'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: senal
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Constelacion
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: senal
  id: parameter
  parameters:
    label: ' vector'
    value: (134,7)
  states: {}

connections:
- [E3TRadio_zero_order_hold2_cc_0, '0', pad_sink_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', E3TRadio_zero_order_hold2_cc_0, '0']

metadata:
  file_format: 1
