options:
  parameters:
    author: Homero Ortega Boada. Universidad industrial de Santander
    category: '''[comdiguis]'''
    description: Entrega una senal BPSK lista para ser entregada a un USRP, pero usando un zero order hold (osea que no usa filtro coseno alzado). Le entrada son unos o ceros tipo float
    generate_options: hb
    id: b_Mod_BPSK
    output_language: python
    title: b_Mod_BPSK_Zeroh
  states: {}

blocks:
- name: E3TRadio_Zero_Order_Hold_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: Sps
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1'
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Samples per Symb
    type: intx
    value: '8'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [E3TRadio_Zero_Order_Hold_0, '0', blocks_float_to_complex_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', E3TRadio_Zero_Order_Hold_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [pad_source_1, '0', E3TRadio_unipolar_to_bipolar_ff_0, '0']

metadata:
  file_format: 1
