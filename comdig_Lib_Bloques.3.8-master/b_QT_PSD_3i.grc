options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb_qt_gui
    id: b_PSD_3i
    output_language: python
    title: b_PSD_3i
  states: {}

blocks:
- name: Amp
  id: parameter
  parameters:
    label: Amplitud
    value: '1'
  states: {}
- name: E3TRadio_vector_average_hob_0
  id: E3TRadio_vector_average_hob
  parameters:
    N: N
    Nensayos: '1000000000'
  states: {}
- name: E3TRadio_vector_average_hob_0_0
  id: E3TRadio_vector_average_hob
  parameters:
    N: N
    Nensayos: '1000000000'
  states: {}
- name: E3TRadio_vector_average_hob_0_1
  id: E3TRadio_vector_average_hob
  parameters:
    N: N
    Nensayos: '1000000000'
  states: {}
- name: Ensayos
  id: parameter
  parameters:
    label: N_ensayos
    value: '1000000'
  states: {}
- name: N
  id: parameter
  parameters:
    label: N_FFT
    value: '1024'
  states: {}
- name: Subtitulo0
  id: parameter
  parameters:
    label: Subtitulo0
    value: '''espectro0'''
  states: {}
- name: Subtitulo1
  id: parameter
  parameters:
    label: Subtitulo1
    value: '''espectro1'''
  states: {}
- name: Subtitulo2
  id: parameter
  parameters:
    label: Subtitulo2
    value: '''espectro2'''
  states: {}
- name: Titulo
  id: parameter
  parameters:
    label: Titulo
    value: '''espectro'''
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./(Ensayos*N))
    type: float
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./(Ensayos*N))
    type: float
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./(Ensayos*N))
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pad_source_2_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pad_source_2_0_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    label1: Subtitulo0
    label2: Subtitulo1
    label3: Subtitulo2
    name: Titulo
    nconnections: '3'
    showports: 'True'
    vlen: N
    width1: '4'
    width2: '4'
    width3: '4'
    x_axis_label: '"Frecuencia"'
    x_start: '-samp_rate_audio/2'
    x_step: (samp_rate_audio-1)/N
    x_units: '"Hz"'
    y_axis_label: '"Amplitud (Watt/Hz)"'
    y_units: '"Watt/Hz"'
    ymax: 1./Ensayos
    ymin: '-1./(4*Ensayos)'
  states: {}
- name: samp_rate_audio
  id: parameter
  parameters:
    label: Fmuestreo
    value: '22000'
  states: {}

connections:
- [E3TRadio_vector_average_hob_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [E3TRadio_vector_average_hob_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [E3TRadio_vector_average_hob_0_1, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_const_source_x_0_0, '0', blocks_float_to_complex_0_1, '1']
- [blocks_complex_to_mag_squared_0, '0', E3TRadio_vector_average_hob_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', E3TRadio_vector_average_hob_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', E3TRadio_vector_average_hob_0_1, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_complex_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_multiply_const_vxx_0_0_1, '0', qtgui_vector_sink_f_0, '2']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [pad_source_2, '0', blocks_float_to_complex_0, '0']
- [pad_source_2_0, '0', blocks_float_to_complex_0_0, '0']
- [pad_source_2_0_0, '0', blocks_float_to_complex_0_1, '0']

metadata:
  file_format: 1
