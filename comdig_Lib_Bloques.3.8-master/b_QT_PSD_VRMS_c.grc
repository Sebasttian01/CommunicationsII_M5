options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb_qt_gui
    id: b_PSD_VRMS_c
    output_language: python
    title: b_PSD_VRMS_c
  states: {}

blocks:
- name: E3TRadio_vector_average_hob_0
  id: E3TRadio_vector_average_hob
  parameters:
    N: N
    Nensayos: '1000000000'
  states: {}
- name: Ensayos
  id: parameter
  parameters:
    label: N_ensayos
    type: intx
    value: '1000000'
  states: {}
- name: Fc
  id: parameter
  parameters:
    label: Fc
    value: '10000'
  states: {}
- name: N
  id: parameter
  parameters:
    label: N_FFT
    type: intx
    value: '1024'
  states: {}
- name: Titulo
  id: parameter
  parameters:
    label: Titulo
    value: ''
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: N
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./N)
    type: float
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.full(N,1./(Ensayos*N))
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: mainwidget3
  id: qtgui_tab_widget
  parameters:
    label0: PSD (Watts/Hz)
    label1: Espectro Dinamico en Volts/Hz
    num_tabs: '2'
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: Tx
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: mainwidget3@0:0,0,1,1
    name: Titulo
    showports: 'True'
    vlen: N
    width1: '3'
    x_axis_label: '"Frecuencia"'
    x_start: '-samp_rate_audio/2+Fc'
    x_step: (samp_rate_audio-1)/N
    x_units: '"Hz"'
    y_axis_label: '"Amplitud (Watt/Hz)"'
    y_units: '"Watt/Hz"'
    ymax: '6e-6'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: mainwidget3@1:0,0,1,1
    name: Titulo
    showports: 'True'
    vlen: N
    width1: '3'
    x_axis_label: '"Frecuency"'
    x_start: '-samp_rate_audio/2+Fc'
    x_step: (samp_rate_audio-1)/N
    x_units: '"Hz"'
    y_axis_label: '"Amplitud (V/Hz)"'
    y_units: '"V"'
    ymax: '0.14'
    ymin: '0'
  states: {}
- name: samp_rate_audio
  id: parameter
  parameters:
    label: Fmuestreo
    value: '22000'
  states: {}

connections:
- [E3TRadio_vector_average_hob_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', E3TRadio_vector_average_hob_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_2, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
