options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander'
    category: '''[comdiguis]'''
    description: 'It is the Root Nyquist Filter in a proof period. I means that that two of this blocks, for example one on the transmitter and one on the receiver form a Nyquist Filter. Parameters: Sps - the number of samples per simbol the filter will produce; ntaps- the number of components in the impulse response'
    generate_options: hb
    id: b_RNyquis_Filter_cc
    output_language: python
    title: b_RNyquist_Filter_cc
  states: {}

blocks:
- name: Amp
  id: variable
  parameters:
    value: numpy.amax(taps)
  states: {}
- name: n_vector
  id: variable
  parameters:
    value: numpy.linspace(ntaps_min,ntaps_max,ntaps)
  states: {}
- name: ntaps_max
  id: variable
  parameters:
    value: abs(ntaps_min)-1+math.ceil(ntaps/2.-abs(ntaps_min))
  states: {}
- name: ntaps_min
  id: variable
  parameters:
    value: '-int(ntaps/2)'
  states: {}
- name: taps
  id: variable
  parameters:
    value: numpy.sqrt(numpy.sinc(n_vector/Sps))
  states: {}
- name: Ganancia
  id: parameter
  parameters:
    label: Ganancia
    type: eng_float
    value: '1.'
  states: {}
- name: Interpolation
  id: parameter
  parameters:
    label: Interpolation
    type: intx
    value: '1'
  states: {state: disabled}
- name: Sps
  id: parameter
  parameters:
    type: intx
    value: '8'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ganancia
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: taps/Amp
    type: ccc
  states: {}
- name: ntaps
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: h[n]
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_vector_source_x_0_0, '0', pad_sink_0_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
