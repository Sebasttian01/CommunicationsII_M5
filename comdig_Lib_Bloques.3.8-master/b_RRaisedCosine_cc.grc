options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander'
    category: '''[comdiguis]'''
    description: 'It is the Root Raised Cosine Filter. Usually gnuradio comes with the square root variant, but this is the right one. Parameters: rolloff - is the rolloff factor or Exccess Bandwidth;  sps - the number of samples per simbol the filter will produce; ntaps- the number of components in the impulse response. Note that if you use two such blocks one in the transmiter (Tx) and one in the receiver (Rx) to obtain a matched filter, equivalent to a RC Filter that satisfies the Nyquist ISI Criterion, the configuration have to be this way: At the Tx give: interpolation=samples per symbol, ntaps= samples per symbol * number of taps; at the receiver give:  intepolation=1; ntaps=number of taps'
    generate_options: hb
    id: b_RRaised_cosine_cc
    output_language: python
    title: b_RRaised_cosine_cc
  states: {}

blocks:
- name: Amp
  id: variable
  parameters:
    value: numpy.amax(rrc_taps)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, rolloff, ntaps)
  states: {}
- name: Ganancia
  id: parameter
  parameters:
    label: Ganancia
    type: eng_float
    value: '1.'
  states: {}
- name: Interpolation
  id: parameter
  parameters:
    label: Interpolation
    type: intx
    value: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ganancia
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: rrc_taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Interpolation
    taps: rrc_taps/Amp
    type: ccc
  states: {}
- name: ntaps
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: h[n]
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '8'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_vector_source_x_0_0, '0', pad_sink_0_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
