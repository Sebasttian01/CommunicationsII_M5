options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander'
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'It is the Raised Cosine Filter. Usually gnuradio comes with the square root variant, but this is the right one. This version2 is more computing economic than the first one. Parameters: rolloff - is the rolloff factor or Exccess Bandwidth;  sps - the number of samples per simbol the filter will produce, but it is at the same time, the interpolation factor. Note that at the input must be only one sample per simbol; ntaps - the number of components of the Impulse response to take into account; the signal at the output will be interpolated by a factor of sps'
    generate_options: hb
    id: b_Raised_cosine2_cc
    output_language: python
    title: b_Raised_cosine2_cc
  states: {}

blocks:
- name: Amp
  id: variable
  parameters:
    value: numpy.amax(rc_taps_a)
  states: {}
- name: rc_taps
  id: variable
  parameters:
    value: rc_taps_a/Amp
  states: {}
- name: rc_taps_a
  id: variable
  parameters:
    value: numpy.convolve(rrc_taps,rrc_taps,mode='same')
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, rolloff, ntaps)
  states: {}
- name: Ganancia
  id: parameter
  parameters:
    label: Ganancia
    type: eng_float
    value: '1.'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ganancia
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: rc_taps
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rc_taps
    type: ccc
  states: {}
- name: ntaps
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: h[n]
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '8'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_vector_source_x_0_0, '0', pad_sink_0_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
