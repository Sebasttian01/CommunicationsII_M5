options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander'
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'It is the Raised Cosine Filter. Usually gnuradio comes with the square root variant, but this is the right one. Parameters: rolloff - is the rolloff factor or Exccess Bandwidth;  sps - the number of samples per simbol the filter will produce. Note that at the input must be only one sample per simbol; ntaps - the number of components of the Impulse response to take into account; samp_rate - the sample rate at the output'
    generate_options: hb
    id: b_Raised_cosine
    output_language: python
    title: b_Raised_cosine_cc
  states: {}

blocks:
- name: ntaps
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rolloff
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    gain: '2'
    interp: sps
    ntaps: ntaps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    gain: '2'
    interp: '1'
    ntaps: ntaps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_ccf
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000'
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '8'
  states: {}

connections:
- [pad_source_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
