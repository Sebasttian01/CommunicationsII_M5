options:
  parameters:
    author: 'Done by: Homero Ortega Boada. Universidad Industrial de Santander.'
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: It is the float type version of the Raised Cosine Filter. Usually gnuradio comes with the square root variant, but this is the right one . You can introduce the rolloff factor (rolloff), the number of samples you want the filter produce at the output per each input symbol (sps) and of course, the number of components to take into account in the impulse response of the filter (ntaps)
    generate_options: hb
    id: b_Raised_cosine_ff
    output_language: python
    title: b_Raised_cosine_ff
  states: {}

blocks:
- name: ntaps
  id: parameter
  parameters:
    type: intx
    value: '16'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: rolloff
  id: parameter
  parameters:
    type: eng_float
    value: '1'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    gain: '2'
    interp: sps
    ntaps: ntaps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: rolloff
    gain: '2'
    interp: '1'
    ntaps: ntaps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: interp_fir_filter_fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: '1000'
  states: {}
- name: sps
  id: parameter
  parameters:
    type: intx
    value: '8'
  states: {}

connections:
- [pad_source_0, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
