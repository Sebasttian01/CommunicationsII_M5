options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Este bloque es el simulador de un canal inalambrico que incluye 2 USRPs, uno en la parte transmisora y otro en la receptora. Se puede usar cuando no se tengan USRP fisicos a la mano. Parametros usados: samp_rate (Hz) es la frecuencia de muestreo de la señal que entra y la que sale de este bloque; Center freq (Hz) frecuencia central del canal inalambrico; Bandwidth  (Hz) ancho de banda pasobandas del canal inalambrico; ; Toffset (numero de muestras de offset) permtite programar un tiempo de retardo de la senal en propagacion; Foffset (Hz) permite programar una desviacion entre la frecuencia central usada en la transmision y la usada en la recepcion; Phoffset (Rad) permite programar una desviacion entre el angulo de la portadora usada en transmision y la usada en recepcion; Vruido (volt) nivel del ruido blanco; Katt (lineal) nivel de atenuacion que la senal transmitida sufre en el proceso de propagacion.'
    generate_options: hb
    id: b_USRP_2_USRP
    output_language: python
    title: b_USRP_2_USRP
  states: {}

blocks:
- name: B
  id: parameter
  parameters:
    label: Bandwidth (Hz)
    type: eng_float
    value: '130000'
  states: {}
- name: Fc
  id: parameter
  parameters:
    label: Center Freq (Hz)
    type: eng_float
    value: '200000000'
  states: {}
- name: Foffset
  id: parameter
  parameters:
    label: Foffset
    type: eng_float
    value: '0.'
  states: {}
- name: Katt
  id: parameter
  parameters:
    label: Katt
    type: eng_float
    value: '10.'
  states: {}
- name: Phoffset
  id: parameter
  parameters:
    label: Phoffset
    type: eng_float
    value: (numpy.pi)*2*random.random()
  states: {}
- name: Toffset
  id: parameter
  parameters:
    label: Toffset
    type: intx
    value: '5'
  states: {}
- name: Vruido
  id: parameter
  parameters:
    label: Vruido
    type: eng_float
    value: '0.'
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: cmath.exp(1j * Phoffset)
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Vruido
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Foffset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Toffset
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./Katt+0j
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_1_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: B/2.
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: B/8.
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: 100e6/512
  states: {}

connections:
- [analog_const_source_x_1_0, '0', blocks_multiply_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
