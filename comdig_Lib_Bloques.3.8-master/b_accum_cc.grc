options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: Hace lo mismo que el acum, pero con senales complejas. Es un acumulador que se resetea cada N muestras. Arranca en la muestra M.
    generate_options: hb
    id: b_accum_cc
    output_language: python
    title: b_accum_cc
  states: {}

blocks:
- name: E3TRadio_acumulador_truncado_ff_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: M
    N: N
  states: {}
- name: E3TRadio_acumulador_truncado_ff_0_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: M
    N: N
  states: {}
- name: M
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: N
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_acumulador_truncado_ff_0, '0', blocks_float_to_complex_0, '1']
- [E3TRadio_acumulador_truncado_ff_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '0', E3TRadio_acumulador_truncado_ff_0_0, '0']
- [blocks_complex_to_float_0, '1', E3TRadio_acumulador_truncado_ff_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
