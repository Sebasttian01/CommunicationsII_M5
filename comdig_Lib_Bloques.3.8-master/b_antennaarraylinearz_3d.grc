options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo de Investigacion RadioGIS Universidad Industrial de Santander
    description: Simula el comportamiento del hardware de un arreglo de antenas más basico que es el caso en que los radiadores están dispuestos de manera lineal, sobre el eje z, donde Dz es la distancia entre los radiadores dada en longitudes de onda, por ejemplo Dz=0.5 significa media longitud de onda. N es el numeo de radiadores, distancias es la distantacia desde z=0 hasta cada radiador; fases son los desfases que sufre cada señal para llegar a un punto de observación ubicado en un angulo theta_i
    generate_options: hb
    id: b_antennaarraylinearz_3d
    output_language: python
    title: b_antennaarraylinearz_3d
  states: {}

blocks:
- name: L_angu
  id: variable
  parameters:
    value: '10'
  states: {}
- name: N
  id: variable
  parameters:
    value: '4'
  states: {}
- name: distancias
  id: variable
  parameters:
    value: Dz*numpy.array(range(N))
  states: {}
- name: fases
  id: variable
  parameters:
    value: '-2*numpy.pi*distancias*numpy.cos(theta_i_gr*numpy.pi/180)'
  states: {}
- name: Dz
  id: parameter
  parameters:
    label: separacion en lambdas
    type: eng_float
    value: '0.5'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.exp(1j*fases[0])
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.exp(1j*fases[1])
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.exp(1j*fases[2])
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_2
  id: blocks_multiply_const_vxx
  parameters:
    const: numpy.exp(1j*fases[3])
    type: complex
  states: {}
- name: desfases
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy
      L_ang=10
      numpy.linspace(-numpy.pi,numpy.pi,L_ang)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in3
    type: complex
  states: {}
- name: pad_source_0_1
  id: pad_source
  parameters:
    label: in2
    type: complex
  states: {}
- name: phi_i_gr
  id: parameter
  parameters:
    label: angulo phi
    value: numpy.linspace(-numpy.pi, numpy.pi, 10)
  states: {}
- name: theta_i_gr
  id: parameter
  parameters:
    label: angulo theta
    value: numpy.array([0,1,2,3])
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_1_2, '0', blocks_add_xx_0, '3']
- [pad_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [pad_source_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [pad_source_0_0_0, '0', blocks_multiply_const_vxx_1_2, '0']
- [pad_source_0_1, '0', blocks_multiply_const_vxx_1_1, '0']

metadata:
  file_format: 1
