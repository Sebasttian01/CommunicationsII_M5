options:
  parameters:
    author: Homero Ortega
    category: '''[en_prueba]'''
    copyright: Grupo de Investigacion RadioGIS Universidad Industrial de Santander
    description: Simula el comportamiento del hardware de un arreglo de antenas más basico que es el caso en que los radiadores están dispuestos de manera lineal, sobre el eje z, donde Dz es la distancia entre los radiadores dada en longitudes de onda, por ejemplo Dz=0.5 significa media longitud de onda. N es el numeo de radiadores, distancias es la distantacia desde z=0 hasta cada radiador; fases son los desfases que sufre cada señal para llegar a un punto de observación ubicado en un angulo theta_i
    generate_options: hb
    id: b_antennaarraylinearz_p
    output_language: python
    title: b_antennaarraylinearz_p
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '4'
  states: {}
- name: distancias
  id: variable
  parameters:
    value: Dz*np.array(range(N))
  states: {}
- name: Dz
  id: parameter
  parameters:
    label: separacion en lambdas
    type: eng_float
    value: '0.5'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Calculo los pesos complejos que afectan a la onda debido a la ubicacion del elemento radiador en el espacio"""

          def __init__(self,N=4,distancias=(0,0,0,0)):
              """fase_weight"""
              gr.sync_block.__init__(
                  self,
                  name='fase_weight',   
                  in_sig=[np.float32],
                  out_sig=[np.complex64]*4
              )
              self.distancias = distancias
              self.N=N

          def work(self, input_items, output_items):
              theta_i_gr=input_items[0]
              fases=-2*np.pi*self.distancias*np.cos(theta_i_gr*np.pi/180)
              output_items[:] = np.exp(fases*1j)
              return len(output_items[0])
    distancias: distancias
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in3
    type: complex
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: theta
    type: float
  states: {}
- name: pad_source_0_1
  id: pad_source
  parameters:
    label: in2
    type: complex
  states: {}
- name: phi_i_gr
  id: parameter
  parameters:
    label: angulo phi
    type: eng_float
    value: '0'
  states: {}
- name: theta_i_gr
  id: parameter
  parameters:
    label: angulo theta
    type: eng_float
    value: '0'
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [epy_block_0, '0', blocks_multiply_xx_0, '1']
- [epy_block_0, '1', blocks_multiply_xx_0_0, '1']
- [epy_block_0, '2', blocks_multiply_xx_0_0_0, '1']
- [epy_block_0, '3', blocks_multiply_xx_0_0_0_0, '1']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_0_0, '0', blocks_multiply_xx_0_0, '0']
- [pad_source_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [pad_source_0_0_0_0, '0', epy_block_0, '0']
- [pad_source_0_1, '0', blocks_multiply_xx_0_0_0, '0']

metadata:
  file_format: 1
