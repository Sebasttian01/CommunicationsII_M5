options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santader
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Genera una senal binaria bipolar aleatoria tipo float. Parametros usados: : Spb (Samples per bit), es para cuando desees que la senal binaria aparezca en forma discreta con un determinado numero de muestras en cada bit'
    generate_options: hb
    id: b_binary_bipolar_source_f
    output_language: python
    title: b_binary_bipolar_source_f
  states: {}

blocks:
- name: Am
  id: parameter
  parameters:
    label: Amplitud
    type: eng_float
    value: '1.'
  states: {}
- name: E3TRadio_Zero_Order_Hold_0
  id: E3TRadio_Zero_Order_Hold
  parameters:
    k: Spb
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {}
- name: Spb
  id: parameter
  parameters:
    label: Spb
    value: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Am
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}

connections:
- [E3TRadio_Zero_Order_Hold_0, '0', pad_sink_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [blocks_int_to_float_0, '0', E3TRadio_unipolar_to_bipolar_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_Zero_Order_Hold_0, '0']

metadata:
  file_format: 1
