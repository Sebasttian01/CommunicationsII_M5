options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santader
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'This is a binary vector generator. Its is useful to produce a paquet of bits that generates repeatly. The paquet of bits corresponds to the binary version of the parameter Vector. Examples for the parameter Vector are:   [100]  or  [101, 54, 12]. What the block does is to traslate the values of the vector to bits and then to type float'
    generate_options: hb
    id: b_binary_gen_vec
    output_language: python
    title: b_binary_vect_source_f
  states: {}

blocks:
- name: Vector
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Vector
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}

connections:
- [blocks_char_to_float_0_0_0, '0', pad_sink_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
