options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb
    id: b_char2complex
    output_language: python
    title: b_char2complex
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_char_to_float_0_0, '0']
- [pad_source_1, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
