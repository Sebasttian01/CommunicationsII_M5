options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: para cada muestra entrante produce uno  si supera el Umbral=0, o cero en otro caso
    generate_options: hb
    id: b_decisor_fb
    output_language: python
    title: 'b_decisor_fb '
  states: {}

blocks:
- name: Constelacion
  id: variable
  parameters:
    value: '[-1.+0.j ,1.+0.j,  ]'
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: Constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: (1,2)
    type: calcdist
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [digital_constellation_decoder_cb_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
