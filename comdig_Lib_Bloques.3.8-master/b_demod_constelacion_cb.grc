options:
  parameters:
    author: Grupo RadioGis Universidad Industrial de Santander
    category: '''[comdiguis]'''
    generate_options: hb
    id: b_demod_constelacion_cb
    output_language: python
    title: b_demod_constelacion_cb
  states: {}

blocks:
- name: Constelacion
  id: variable
  parameters:
    value: '[(raiz2 + raiz2*1j),  (-raiz2 + raiz2*1j), (-raiz2 - raiz2*1j), (raiz2 - raiz2*1j)]'
  states: {state: disabled}
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: Constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: mapa
    type: calcdist
  states: {}
- name: mapa
  id: variable
  parameters:
    value: numpy.arange(M)
  states: {}
- name: raiz2
  id: variable
  parameters:
    value: 2**(1/2)
  states: {state: disabled}
- name: Constelacion
  id: parameter
  parameters:
    label: Constelacion
    value: '[(1.41 + 1.41*1j),  (-1.41 + 1.41*1j), (-1.41 - 1.41*1j), (1.41 - 1.41*1j)]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [digital_constellation_decoder_cb_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
