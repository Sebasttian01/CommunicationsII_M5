options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'saca la derivada a una senal compleja: parte real e imaginaria por aparte. a cada una le sca una diferencia y la divide entre el tiempo de muestreo'
    generate_options: hb
    id: b_derivador_ff
    output_language: python
    title: b_derivador_ff
  states: {}

blocks:
- name: F_muestreo
  id: parameter
  parameters:
    label: F_muestreo
    type: eng_float
    value: '1000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: F_muestreo
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_delay_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', pad_sink_1, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_sub_xx_0, '0']

metadata:
  file_format: 1
