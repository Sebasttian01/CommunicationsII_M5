options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: Demultiplexa una senal que ha sido multiplexada con el bloque b_TDM
    generate_options: hb
    id: b_deTDM_cc
    output_language: python
    title: b_deTDM_cc
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Nspcell
  id: parameter
  parameters:
    label: simb per t-s
    value: '16'
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell*N
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: N
    type: complex
    vlen: Nspcell
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_1_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_2
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_stream_to_vector_0_0_0_0_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_vector_to_stream_1_0, '0', pad_sink_0_0_0_0, '0']
- [blocks_vector_to_stream_1_0_0, '0', pad_sink_0_1_0, '0']
- [blocks_vector_to_stream_1_0_0_0, '0', pad_sink_0_2, '0']
- [blocks_vector_to_stream_1_0_0_0_0, '0', pad_sink_0, '0']
- [blocks_vector_to_stream_1_0_0_1, '0', pad_sink_0_1, '0']
- [blocks_vector_to_stream_1_0_1, '0', pad_sink_0_0_1, '0']
- [blocks_vector_to_stream_1_0_1_0, '0', pad_sink_0_0, '0']
- [blocks_vector_to_stream_1_0_2, '0', pad_sink_0_0_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_vector_to_stream_1_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_vector_to_stream_1_0_1_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_vector_to_stream_1_0_0_1, '0']
- [blocks_vector_to_streams_0, '3', blocks_vector_to_stream_1_0_2, '0']
- [blocks_vector_to_streams_0, '4', blocks_vector_to_stream_1_0_0_0, '0']
- [blocks_vector_to_streams_0, '5', blocks_vector_to_stream_1_0_1, '0']
- [blocks_vector_to_streams_0, '6', blocks_vector_to_stream_1_0_0, '0']
- [blocks_vector_to_streams_0, '7', blocks_vector_to_stream_1_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0_0_0_0_0, '0']

metadata:
  file_format: 1
