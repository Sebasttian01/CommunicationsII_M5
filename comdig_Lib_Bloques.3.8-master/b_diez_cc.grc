options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: RadioGis UIS
    description: |
      Realiza un diezmado del mundo real. N es la distancia entre las muestras a diezmar (En el caso de requerir diezmar una senal digitales equivale a Sps (Samples per symbol)), M es el punto de inicio.
    generate_options: hb
    id: b_diez_cc
    output_language: python
    title: b_diez_cc
  states: {}

blocks:
- name: E3TRadio_diezmador_cc_0
  id: E3TRadio_diezmador_cc
  parameters:
    paso: N
  states: {}
- name: M
  id: parameter
  parameters:
    label: M
    type: intx
    value: '0'
  states: {}
- name: N
  id: parameter
  parameters:
    label: N
    type: intx
    value: '8'
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: M
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_diezmador_cc_0, '0', pad_sink_0, '0']
- [blocks_delay_0_0, '0', E3TRadio_diezmador_cc_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']

metadata:
  file_format: 1
