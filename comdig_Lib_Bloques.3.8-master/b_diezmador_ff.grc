options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    generate_options: hb
    id: b_diezmador_ff
    output_language: python
    title: b_diezmador_ff
  states: {}

blocks:
- name: E3TRadio_diezmador_cc_0
  id: E3TRadio_diezmador_cc
  parameters:
    paso: Paso
  states: {}
- name: Paso
  id: parameter
  parameters:
    label: Paso
    value: '2'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [E3TRadio_diezmador_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', pad_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [blocks_float_to_complex_0, '0', E3TRadio_diezmador_cc_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_2, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
