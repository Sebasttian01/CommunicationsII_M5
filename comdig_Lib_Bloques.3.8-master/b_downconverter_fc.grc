options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'Es un downconverter. Los parametros usados son: samp_rate (Hz): es la frecuencia de muestreo que es igual para senal entrante y para la saliente; Fc (Hz) es la frecuencia de la portadora que sera generada; BW (Hz) ancho de banda de la senal bandabase esperada. Nota: es importante resaltar de nuevo, que la senal entrante debe estar muestreada a la misma razon que se espera para la senal saliente.'
    generate_options: hb
    id: b_downconverter_fc
    output_language: python
    title: b_downconverter_fc
  states: {}

blocks:
- name: BW
  id: parameter
  parameters:
    label: BW
    value: '11000'
  states: {}
- name: Fc
  id: parameter
  parameters:
    label: Fc
    value: '16000'
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-2'
    freq: Fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '2'
    freq: Fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: BW/16.
    win: window.WIN_RECTANGULAR
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: BW/16.
    win: window.WIN_RECTANGULAR
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '44000'
  states: {}

connections:
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [pad_source_0_0, '0', blocks_multiply_xx_0_1, '1']

metadata:
  file_format: 1
