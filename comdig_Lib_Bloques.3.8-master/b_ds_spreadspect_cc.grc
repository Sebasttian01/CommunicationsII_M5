options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'multiplica la entrada por codigo para producir una senal en Direc Sequence Spread Spectrum (DSSS). El cuidado que hay que tener es que el Spreading Factor (SF) se cuadra desde afuera, para la cual la senal de la informacion debe entrar con un sobremuestreo SF. Los parametros usados son: codigo - es el codigo que se usara para producir la senal DSSS'
    generate_options: hb
    id: b_ds_spreadspect_cc
    output_language: python
    title: b_ds_spreadspect_cc
  states: {}

blocks:
- name: E3TRadio_zero_order_hold2_cc_0
  id: E3TRadio_zero_order_hold2_cc
  parameters:
    k: SF
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '8'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: codigo
  states: {}
- name: codigo
  id: parameter
  parameters:
    label: codigo
    value: (1,1,1,1,1,1,1,1)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: cod
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: info
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_zero_order_hold2_cc_0, '0', blocks_multiply_xx_0, '0']
- [E3TRadio_zero_order_hold2_cc_0, '0', pad_sink_0_0_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_0, '0', pad_sink_0_0, '0']
- [pad_source_0, '0', E3TRadio_zero_order_hold2_cc_0, '0']

metadata:
  file_format: 1
