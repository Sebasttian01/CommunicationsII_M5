options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGis Universidad Industrial de Santander
    description: 'multiplica la entrada por codigo para producir una senal en Direc Sequence Spread Spectrum (DSSS) para una entrada y salida flotante. El cuidado que hay que tener es que el Spreading Factor (SF) se cuadra desde afuera, para la cual la senal de la informacion debe entrar con un sobremuestreo SF. Los parametros usados son: codigo - es el codigo que se usara para producir la senal DSSS; retardo (muestras) es para tener en cuenta que la senal entrante puede estar llegando con un retardo, el cual debe ser compensado con un retardo en la entrada del codigo'
    generate_options: hb
    id: b_ds_spreadspect_ff
    output_language: python
    title: b_ds_spreadspect_ff
  states: {}

blocks:
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: retardo
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: codigo
  states: {}
- name: codigo
  id: parameter
  parameters:
    label: codigo
    value: (1,1,1,1,1,1,1,1)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: retardo
  id: parameter
  parameters:
    label: retardo
    type: intx
    value: '0'
  states: {}

connections:
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
