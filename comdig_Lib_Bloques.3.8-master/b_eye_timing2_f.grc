options:
  parameters:
    author: Homero Ortega
    category: '''[version_vieja]'''
    description: 'permite visualizar el diagrama de ojo y el instante del timing. Parametros usados: N es el numero de muestras en el intervalo de tiempo a graficar, se recomienda que N=2*Sps, donde Sps es el numero de muestras por simbolo; samp_rate es la frecuencia de muestreo; Delay es el retraso que se le puede aplicar a la senal para centrar mejor el ojo'
    generate_options: hb
    id: b_eye_timing2_f
    output_language: python
    title: b_eye_timing2_f
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '64'
  states: {}
- name: Spsi
  id: variable
  parameters:
    value: '32'
  states: {}
- name: Delay
  id: parameter
  parameters:
    label: Delay
    type: intx
    value: '0'
  states: {}
- name: E3TRadio_diezmoppenh3_ff_0
  id: E3TRadio_diezmoppenh3_ff
  parameters:
    M: int((Timing-Sps/2)*Spsi/Sps)
    N: Spsi
  states: {}
- name: E3TRadio_vec_diagrama_ojo2_f_0
  id: E3TRadio_vec_diagrama_ojo2_f
  parameters:
    N: Spsi*2
    samp_rate: samp_rate*Spsi/Sps
  states: {state: disabled}
- name: Nvol
  id: parameter
  parameters:
    label: N curvas
    type: intx
    value: '100'
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    type: intx
    value: '8'
  states: {}
- name: Timing
  id: parameter
  parameters:
    label: Timing
    type: intx
    value: '0'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Delay
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: Spsi*2, Spsi*2
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N
    Ncurvas: Nvol
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import matplotlib.pyplot as plt

      class vec_diagrama_ojo2_f(gr.sync_block):
          """
          Diagrama de ojo. Hecho por Homero Ortega Boada. Universida Industrial de Santander.
      N: es el numero de muestras que ocupara el ojo, se recomienda que N=Sps*2, donde Sps es el numero de muestras por simbolo.
      samp_rate: es la frecuencia de muestreo de la senal.
          """
          def __init__(self, N=64, samp_rate=32000, Ncurvas=100):
              gr.sync_block.__init__(self,
                  name="e_vec_diagrama_ojo2_f",
                  in_sig=[(np.float32, N)],
                  out_sig=None)
              #########################################
              ##        Parametros                   ##
              #########################################
              self.Sps = int(N/2)
              self.Tsamp=1./samp_rate
              Tb=self.Sps*self.Tsamp
              self.t = np.linspace(-Tb,Tb, 2*self.Sps)
              self.Ncurvas=Ncurvas
              self.contador=0

          def work(self, input_items, output_items):
              in0 = input_items[0] # in0 es un 2D array (como una matrix)
              s=in0[0]    # Esto traduce el 2D array a 1D array (a un vector)
              #plt.plot(self.t,s)             
              #plt.pause(self.Tsamp)
              if self.contador < self.Ncurvas:
                  plt.plot(self.t,s)
                  plt.pause(self.Tsamp)
                  self.contador += 1
              else:
                  self.contador=0
                  plt.clf()
              return len(input_items[0])
    samp_rate: samp_rate
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Sps
    interp: Spsi
    taps: ''
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: '32000'
  states: {}

connections:
- [E3TRadio_diezmoppenh3_ff_0, '0', blocks_stream_mux_0, '1']
- [blocks_delay_0, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', E3TRadio_vec_diagrama_ojo2_f_0, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', E3TRadio_diezmoppenh3_ff_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_mux_0, '0']

metadata:
  file_format: 1
