options:
  parameters:
    author: Andres Carrillo
    category: '''[comdiguis]'''
    copyright: b_FDM_Monousuario
    description: produce senal FSK bandabase
    generate_options: hb
    id: b_fsk_fc
    output_language: python
    title: b_fsk_fc
  states: {}

blocks:
- name: BW
  id: parameter
  parameters:
    label: Band Width
    value: '0'
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Sps
    value: '8'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: f0
  id: parameter
  parameters:
    label: f0
    value: '0'
  states: {}
- name: interp_fir_filter_xxx_0_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: 'Sps*[1.,] '
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: BW/8.
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '4800'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', interp_fir_filter_xxx_0_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '1']
- [interp_fir_filter_xxx_0_0_0, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
