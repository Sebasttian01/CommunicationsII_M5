options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Hace lo mismo que el b_acum_cc, pero divide por el numero de muestras acumulados con lo cual se obtiene un integrador que se resetea cada N muestras. Es un acumulador que se resetea cada N muestras. Arranca en la muestra M.
    generate_options: hb
    id: b_integrador
    output_language: python
    title: b_integrador
  states: {}

blocks:
- name: E3TRadio_acumulador_truncado_ff_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: M
    N: N
  states: {}
- name: E3TRadio_acumulador_truncado_ff_0_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: M
    N: N
  states: {}
- name: M
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: N
  id: parameter
  parameters:
    type: intx
    value: '8'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1./N +0.j
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_acumulador_truncado_ff_0, '0', blocks_float_to_complex_0, '1']
- [E3TRadio_acumulador_truncado_ff_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '0', E3TRadio_acumulador_truncado_ff_0_0, '0']
- [blocks_complex_to_float_0, '1', E3TRadio_acumulador_truncado_ff_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
