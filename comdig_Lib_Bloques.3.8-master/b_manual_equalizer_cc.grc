options:
  parameters:
    category: '''[comdiguis]'''
    generate_options: hb
    id: b_Manual_Equalizer_cc
    output_language: python
    title: b_Manual_Equalizer_cc
  states: {}

blocks:
- name: Eq_taps
  id: variable
  parameters:
    value: fftpack.ifftshift(fftpack.ifft([taps[0], taps[1], taps[2], taps[3], taps[4], taps[5], taps[6], taps[7]]))
  states: {}
- name: eq_gain
  id: variable
  parameters:
    value: '0.01'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.'
    freq_offset: '0'
    noise_voltage: '0'
    seed: '13'
    taps: Eq_taps
  states: {}
- name: import_scipy
  id: import
  parameters:
    imports: from scipy import fftpack
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: taps
  id: parameter
  parameters:
    value: '[1,1,1,1,1,1,1,1]'
  states: {}

connections:
- [channels_channel_model_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', channels_channel_model_0_0, '0']

metadata:
  file_format: 1
