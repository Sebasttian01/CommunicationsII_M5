options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Mide potencia promedio en watts y en dB a senales complejas. Tambien el Valor RMS. G_prom: es la ganancia para el filtro promediador, entre mas pequeno sea este valor, el promediado es de mas largo plazo y por tanto, el valor es mas estable'
    generate_options: hb
    id: b_meter_power_cc
    output_language: python
    title: b_meter_power_cc
  states: {}

blocks:
- name: G_prom
  id: parameter
  parameters:
    label: G_prom
    value: '0.0001'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: G_prom
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Potencia
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: Potencia_dB
    type: float
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: Valor_RMS
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_nlog10_ff_0, '0', pad_sink_2, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_rms_xx_0, '0', pad_sink_3, '0']
- [pad_source_0, '0', blocks_rms_xx_0, '0']

metadata:
  file_format: 1
