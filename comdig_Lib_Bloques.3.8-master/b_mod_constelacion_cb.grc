options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    generate_options: hb
    id: b_mod_constelacion_cb
    output_language: python
    title: b_mod_constelacion_cb
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(Constelacion)
  states: {state: disabled}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: Constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: mapa
    type: calcdist
  states: {state: disabled}
- name: mapa
  id: variable
  parameters:
    value: numpy.arange(M)
  states: {state: disabled}
- name: Constelacion
  id: parameter
  parameters:
    label: Constelacion
    value: '[(1.41 + 1.41*1j),  (-1.41 + 1.41*1j), (-1.41 - 1.41*1j), (1.41 - 1.41*1j)]'
  states: {}
- name: digital_chunks_to_symbols_xx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Constelacion
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [digital_chunks_to_symbols_xx, '0', pad_sink_0, '0']
- [pad_source_0, '0', digital_chunks_to_symbols_xx, '0']

metadata:
  file_format: 1
