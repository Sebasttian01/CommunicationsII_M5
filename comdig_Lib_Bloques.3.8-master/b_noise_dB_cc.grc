options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Genera ruido blanco gaussiano en version de envolvente compleja, pidiendo como entrada el valor de la PSD, osea, No en dB. Parametros usados: samp_rate (Hz) es la frecuencia de muestreo de la senal que genera este bloque, NoDB (dB) es la altura de la PSD que como se sabe, para el ruido blanco es una constante'
    generate_options: hb
    id: b_noise_dB_cc
    output_language: python
    title: b_noise_dB_cc
  states: {}

blocks:
- name: 'No'
  id: variable
  parameters:
    value: math.pow(10.,(NodB)/10.)
  states: {}
- name: P
  id: variable
  parameters:
    value: No*samp_rate
  states: {}
- name: Vrms
  id: variable
  parameters:
    value: math.sqrt(P)
  states: {}
- name: NodB
  id: parameter
  parameters:
    label: NodB
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Vrms
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '10000'
  states: {}

connections:
- [analog_noise_source_x_0, '0', pad_sink_1, '0']

metadata:
  file_format: 1
