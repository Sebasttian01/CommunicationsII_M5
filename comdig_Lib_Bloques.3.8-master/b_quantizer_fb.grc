options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Este es un cuantificador que recibe una senal tipo float, la cuantifica y entrega a tipo byte  (que es lo mismo que char en c++).  Funciona bien para cualquier niveles de cuantificacion que este en el rango del tipo Byte. Así, para el tipo Byte el maximo nivel de cuantizacion es 256 (osea 2^8).  Los parametros usados: Vmax: es el valor maximo de amplitud que puede llegar a alcanzar la senal entrante, bien sea en el rango de los valores negativos o en los positivos, pero aqui se registra ese valor sin signo, osea como un valor positivo o valor absoluto ; NivelesQ - es el numero de niveles de cuantificacion a usar en todo el rango dinamico de la senal'
    generate_options: hb
    id: b_quantizer_fb
    output_language: python
    title: b_quantizer_fb
  states: {}

blocks:
- name: NivelesQ
  id: parameter
  parameters:
    label: NivelesQ
    type: intx
    value: '256'
  states: {}
- name: Vmax
  id: parameter
  parameters:
    label: Vmax
    type: eng_float
    value: '.5'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (NivelesQ/2.)/Vmax
    type: float
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_char_0, '0', pad_sink_2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
