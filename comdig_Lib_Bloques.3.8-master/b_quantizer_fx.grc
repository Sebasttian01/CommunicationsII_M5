options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: 'Este es un cuantificaador que recibe una senal tipo float, la cuantifica y entrega en 4 posibles tipos de salida (Byte, short, int  o float).  Funciona bien para cualquier niveles de cuantificacion que este en el rango del tipo de salida de su interes. Por ejemplo, si va a usar la salida tipo Byte, el maximo nivel de cuantizacion es 256 (osea 2^8), si es la tipo short, ese valor es 65536 (osea 2^16), si es tipo int, se supone que ese valor es 2^32. El tipo float lo usamos mas que todo para poder visualizar la senal cuantificada directamente en un osciloscopio.  Los parametros usados: Vmax: es el valor maximo de amplitud que puede llegar a alcanzar la senal entrante, bien sea en el rango de los valores negativos o en los positivos, pero aqui se registra ese valor sin signo, osea como un valor positivo o valor absoluto ; NivelesQ - es el numero de niveles de cuantificacion a usar en todo el rango dinamico de la senal'
    generate_options: hb
    id: b_quantizer_fx
    output_language: python
    title: b_quantizer_fx
  states: {}

blocks:
- name: NivelesQ
  id: parameter
  parameters:
    label: NivelesQ
    type: intx
    value: '256'
  states: {}
- name: Vmax
  id: parameter
  parameters:
    label: Vmax
    type: eng_float
    value: '.5'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (NivelesQ/2.)/Vmax
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: short
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: int
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [blocks_float_to_char_0, '0', pad_sink_2_0, '0']
- [blocks_float_to_int_0, '0', blocks_int_to_float_0, '0']
- [blocks_float_to_int_0, '0', pad_sink_2, '0']
- [blocks_float_to_short_0, '0', pad_sink_0, '0']
- [blocks_int_to_float_0, '0', pad_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_int_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
