options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[en_prueba]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Etiqueta de salida. Para no tener que hacer tantas interconexiones
    generate_options: hb
    id: s
    output_language: python
    title: s
  states: {}

blocks:
- name: I
  id: parameter
  parameters:
    label: Id
    value: '0'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: ''
  states: {}
- name: s1
  id: virtual_sink
  parameters:
    stream_id: I
  states: {}

connections:
- [pad_source_0, '0', s1, '0']

metadata:
  file_format: 1
