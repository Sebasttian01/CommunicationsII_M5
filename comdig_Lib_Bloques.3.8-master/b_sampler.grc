options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Por una salida entrega la senal diezmada y por la otra muestreada. El diezmado se realiza  de la manera en que se explica el diezmado en el libro de Tratamiento de Senales y Sistemas de Oppenheim. En ese diezmado se igualan a cero periodicamente un grupo de muestras. El muestreo, que se entrega en la otra salida de este bloque es similar al diezmado, pero las muestras que se igualan a cero son anuladas, es decir, desaparecen de la senal. Por esa razon, la rata de muestreo de la senal diezmada es la misma de la que entra al bloque, pero la rata de muestreo de la senal muestreada es Sps veces menor.
    generate_options: hb
    id: b_sampler
    output_language: python
    title: b_sampler
  states: {}

blocks:
- name: DelayDiez
  id: parameter
  parameters:
    label: Retrazo
    type: intx
    value: '0'
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: DelayDiez
    N: Sps
  states: {}
- name: E3TRadio_diezmoppenh3_ff_0
  id: E3TRadio_diezmoppenh3_ff
  parameters:
    M: DelayDiez
    N: Sps
  states: {}
- name: Sps
  id: parameter
  parameters:
    label: Samp per symb
    type: intx
    value: '64'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: Diezmado
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [E3TRadio_diezma_ff_0, '0', pad_sink_1, '0']
- [E3TRadio_diezmoppenh3_ff_0, '0', E3TRadio_diezma_ff_0, '0']
- [E3TRadio_diezmoppenh3_ff_0, '0', pad_sink_2, '0']
- [pad_source_0, '0', E3TRadio_diezmoppenh3_ff_0, '0']

metadata:
  file_format: 1
