options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Realiza un muestreo o decimacion de la senal
    generate_options: hb
    id: b_sampler2_cc
    output_language: python
    title: b_sampler2_cc
  states: {}

blocks:
- name: Decimation
  id: parameter
  parameters:
    label: Decimation
    value: '1'
  states: {}
- name: E3TRadio_diezma_ff_0
  id: E3TRadio_diezma_ff
  parameters:
    M: '0'
    N: Decimation
  states: {}
- name: E3TRadio_diezma_ff_0_0
  id: E3TRadio_diezma_ff
  parameters:
    M: '0'
    N: Decimation
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [E3TRadio_diezma_ff_0, '0', blocks_float_to_complex_0, '0']
- [E3TRadio_diezma_ff_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '0', E3TRadio_diezma_ff_0, '0']
- [blocks_complex_to_float_0, '1', E3TRadio_diezma_ff_0_0, '0']
- [blocks_float_to_complex_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
