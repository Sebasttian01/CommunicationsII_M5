options:
  parameters:
    author: Homero Ortega Boada
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Realiza el scrambling
    generate_options: hb
    id: b_scrambling_bf
    output_language: python
    title: b_scrambling_bf
  states: {}

blocks:
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {}
- name: E3TRadio_unipolar_to_bipolar_ff_0_0
  id: E3TRadio_unipolar_to_bipolar_ff
  parameters:
    Amp: '1.'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: semilla
    type: byte
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: semilla
  id: parameter
  parameters:
    label: semilla
    type: intx
    value: '42'
  states: {}

connections:
- [E3TRadio_unipolar_to_bipolar_ff_0, '0', blocks_multiply_xx_0, '0']
- [E3TRadio_unipolar_to_bipolar_ff_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_random_uniform_source_x_0, '0', blocks_char_to_float_0_0_0, '0']
- [blocks_char_to_float_0_0, '0', E3TRadio_unipolar_to_bipolar_ff_0, '0']
- [blocks_char_to_float_0_0_0, '0', E3TRadio_unipolar_to_bipolar_ff_0_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1
