options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: multiplexa hasta N=8 usuarios/n con Nspcell muestras por usuario
    generate_options: hb
    id: b_TDM_cc
    output_language: python
    title: b_TDM_cc
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: Nspcell
  id: parameter
  parameters:
    label: simb per t-s
    value: '8'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: Nspcell
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: N
    type: complex
    vlen: Nspcell
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N*Nspcell
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_0_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_0_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_1_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_0_2
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', blocks_streams_to_vector_0, '3']
- [blocks_stream_to_vector_0_0_0_0, '0', blocks_streams_to_vector_0, '7']
- [blocks_stream_to_vector_0_0_1, '0', blocks_streams_to_vector_0, '5']
- [blocks_stream_to_vector_0_1, '0', blocks_streams_to_vector_0, '2']
- [blocks_stream_to_vector_0_1_0, '0', blocks_streams_to_vector_0, '6']
- [blocks_stream_to_vector_0_2, '0', blocks_streams_to_vector_0, '4']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']
- [pad_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [pad_source_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [pad_source_0_0_0_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [pad_source_0_0_1, '0', blocks_stream_to_vector_0_0_1, '0']
- [pad_source_0_1, '0', blocks_stream_to_vector_0_1, '0']
- [pad_source_0_1_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [pad_source_0_2, '0', blocks_stream_to_vector_0_2, '0']

metadata:
  file_format: 1
