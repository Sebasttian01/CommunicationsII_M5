options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Permite sintonizar la fase y la frecuencia de una senal que llega por un USRP
    generate_options: hb
    id: b_tunner
    output_language: python
    title: b_tunner
  states: {}

blocks:
- name: Ganancia_ajuste_dB
  id: parameter
  parameters:
    label: Ganancia (dB)
    type: intx
    value: '0'
  states: {}
- name: NDelay
  id: parameter
  parameters:
    label: NDelay
    type: intx
    value: '0'
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: cmath.exp(1j * phi)
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: math.pow(10,Ganancia_ajuste_dB/20.)
    freq: fdesv
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: NDelay
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: fdesv
  id: parameter
  parameters:
    label: Frec. Deviation
    type: eng_float
    value: '0'
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_1_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: phi
  id: parameter
  parameters:
    label: Phase (Rad)
    type: eng_float
    value: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    type: eng_float
    value: '1000'
  states: {}

connections:
- [analog_const_source_x_1_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_delay_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
