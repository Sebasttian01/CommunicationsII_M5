options:
  parameters:
    author: Homero Ortega Boada. Universidad Industrial de Santander
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    description: Es un modulador M-PAM con entrada unipolar. La entrada y la salida es de tipo Byte, pero en la entrada lo que se esperan son unos y ceros, osea que la entrada es una senal PCM.
    generate_options: hb
    id: b_u_M_PAM_bb
    output_language: python
    title: b_u_M_PAM_bb
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Nbps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: M
  id: parameter
  parameters:
    label: M
    type: intx
    value: '4'
  states: {}
- name: Nbps
  id: parameter
  parameters:
    value: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: Nbps
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: Bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', pad_sink_1_0, '0']
- [pad_source_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']

metadata:
  file_format: 1
