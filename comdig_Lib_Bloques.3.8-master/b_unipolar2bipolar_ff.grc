options:
  parameters:
    author: Homero Ortega
    category: '''[comdiguis]'''
    copyright: Grupo RadioGIS Universidad Industrial de Santander
    generate_options: hb
    id: b_unipolar2bipolar_ff
    output_language: python
    title: b_unipolar2bipolar_ff
  states: {}

blocks:
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '-1./2.'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.'
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
